Properties of the parts of a building model (IFC2X3), part 4 of 4

# IfcFlowFitting: verzinkt_staal (4)
Type - Description: Rechthoekig - deksel; PredefinedType: USERDEFINED; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal
Group: lu-t 4
Name (NLRS_57_DUF_UN_rechth deksel_Luka:verzinkt_staal:...)
1616291
1616293
1617000
1617023

# IfcFlowFitting: verzinkt_staal (67)
In: 00_Begane Grond
Type - Description: Rond - T-stuk, verkleinend of gelijkzijdig; PredefinedType: JUNCTION; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal
Name (NLRS_57_DUF_UN_rond T-stuk_Luka:verzinkt_staal:...) | Group
1587077 | lu-r 1
1587273 | lu-r 1
1587743 | lu-r 1
1588115 | lu-r 1
1588256 | lu-r 1
1588278 | lu-r 1
1588303 | lu-r 1
1588377 | lu-r 1
1588512 | lu-r 1
1588517 | lu-r 1
1588671 | lu-r 1
1589414 | lu-r 1
1590428 | lu-r 1
1590433 | lu-r 1
1590438 | lu-r 1
1590468 | lu-r 1
1591296 | lu-r 1
1591781 | lu-r 1
1592829 | lu-r 1
1593195 | lu-r 1
1595570 | lu-r 1
1598753 | lu-t 1
1605217 | lu-t 3
1605244 | lu-t 3
1606172 | lu-t 3
1606629 | lu-t 3
1621137 | lu-r 4
1623225 | lu-r 4
1623417 | lu-r 4
1627222 | lu-t 6
1627416 | lu-t 6
1627856 | lu-t 6
1628313 | lu-r 4
1628421 | lu-r 4
1628953 | lu-r 4
1629298 | lu-r 4
1633312 | lu-t 6
1639217 | lu-r 4
1711564 | lu-t 1
1724510 | afb 5
1742632 | lu-t 3
1743333 | lu-t 3
1743443 | lu-t 3
1756532 | lu-t 9
1770244 | lu-t 3
1786777 | lu-r 7
1786957 | lu-r 7
1786966 | lu-r 7
1786975 | lu-r 7
1791239 | lu-r 7
1794313 | lu-r 7
1794357 | lu-r 7
1795531 | lu-r 7
1813778 | lu-r 9
1814039 | lu-r 9
1814046 | lu-r 9
1814053 | lu-r 9
1814557 | lu-r 9
1814610 | lu-r 9
1814828 | lu-r 9
1814849 | lu-r 9
1816305 | lu-r 9
1816323 | lu-r 9
1816369 | lu-r 9
1817020 | lu-r 9
1817052 | lu-r 9
1817061 | lu-r 9

# IfcFlowFitting: verzinkt_staal (6)
In: 00_Begane Grond
Type - Description: Rond - einddeksel tbv ronde kanalen; PredefinedType: USERDEFINED; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal
Name (NLRS_57_DUF_UN_rond deksel buis_Luka:verzinkt_staal:...) | Group
1564552 | lu-t 2
1572927 | lu-t 2
1596179 | lu-t 1
1597446 | lu-t 1
1621465 | lu-t 6
1624155 | lu-t 6

# IfcFlowFitting: verzinkt_staal (31)
In: 00_Begane Grond
Type - Description: Rond - koppelstuk tbv hulpstukken; PredefinedType: CONNECTOR; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_roestvast staal 304(1.4301)
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal
Name (NLRS_57_DUF_UN_rond koppelstuk tbv hulpstukken_Luka:verzinkt_staal:...)
1588506
1589825
1589842
1589863
1591861
1591911
1592885
1595604
1597659
1623778
1627906
1629242
1633361
1633756
1646195
1646198
1724630
1741929
1742631
1742779
1743966
1755517
1755521
1756575
1756576
1787729
1787744
1787745
1816484
1816511
1816512

# IfcFlowFitting: verzinkt_staal (2)
In: 00_Begane Grond
Type - Description: Rond - platte tuit / zadelstuk; PredefinedType: JUNCTION; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal
Name (NLRS_57_DUF_UN_rond platte tuit_Luka:verzinkt_staal:...) | Group
1607557 | lu-r 12
1723917 | bla 6

# IfcFlowFitting: verzinkt_staal (2)
In: 00_Begane Grond
Type - Description: Rond - steekverbindingen tbv ronde kanalen; PredefinedType: CONNECTOR; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal
Name (NLRS_57_DUF_UN_rond steekverbinding_Luka:verzinkt_staal:...) | Group
1684217 | lu-t 1
1770490 | lu-t 3

# IfcFlowFitting: verzinkt_staal (31)
In: 00_Begane Grond
Type - Description: Rond - verloopstuk tbv kanalen; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal
Name (NLRS_57_DUF_UN_rond verloop buis_Luka:verzinkt_staal:...) | Group
1588504 | lu-r 1
1589820 | lu-r 1
1589835 | lu-r 1
1589857 | lu-r 1
1591859 | lu-r 1
1591907 | lu-r 1
1592881 | lu-r 1
1595599 | lu-r 1
1597653 | lu-t 1
1623776 | lu-r 4
1627901 | lu-t 6
1629240 | lu-r 4
1633356 | lu-t 6
1633754 | lu-t 1
1646186 | lu-t 6
1646196 | lu-t 6
1724625 | afb 5
1741927 | lu-t 3
1742629 | lu-t 3
1742774 | lu-t 3
1743964 | lu-t 3
1755513 | lu-t 9
1755519 | lu-t 9
1756571 | lu-t 9
1756573 | lu-t 9
1787727 | lu-r 7
1787739 | lu-r 7
1787741 | lu-r 7
1816478 | lu-r 9
1816504 | lu-r 9
1816506 | lu-r 9

# IfcFlowFitting: verzinkt_staal 2, NLRS_57_DUF_UN_rechth deksel_Luka:verzinkt_staal 2:1606823
In: 00_Begane Grond
Type - Description: Rechthoekig - deksel; PredefinedType: USERDEFINED; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal 2
Group: lu-r 12

# IfcFlowSegment: Flex Duct Round:Flex - Round (9)
In: 00_Begane Grond
Type - PredefinedType: FLEXIBLESEGMENT
Pset_DistributionFlowElementCommon - Reference: Flex - Round
Group: lu-t 3
Name (Flex Duct Round:Flex - Round:...)
1741637
1741807
1742031
1742408
1742502
1744141
1744167
1744175
1744269

# IfcFlowSegment: Pipe Types:NLRS_50_PI_Koper (DN) Mapress_Geberit (253)
In: 00_Begane Grond
Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: NLRS_50_PI_Koper (DN) Mapress_Geberit
Name (Pipe Types:NLRS_50_PI_Koper (DN) Mapress_Geberit:...) | Group
1661283 | kwl 4
1661356 | kwl 4
1661375 | kwl 4
1661392 | kwl 4
1661549 | kwl 4
1661627 | kwl 4
1661646 | kwl 4
1661681 | kwl 4
1661716 | kwl 4
1661735 | kwl 4
1661972 | kwl 4
1662004 | kwl 4
1662066 | kwl 4
1662072 | kwl 4
1662087 | kwl 4
1662499 | kwl 4
1662541 | kwl 4
1662553 | kwl 4
1663143 | kwl 4
1663382 | kwl 4
1663413 | kwl 4
1663580 | kwl 4
1663626 | kwl 4
1663827 | kwl 4
1663834 | kwl 4
1664551 | kwl 4
1664659 | kwl 4
1664722 | kwl 4
1664746 | kwl 4
1664766 | kwl 4
1665062 | kwl 4
1665070 | kwl 4
1665104 | kwl 4
1665108 | kwl 4
1665110 | kwl 4
1665126 | kwl 4
1665130 | kwl 4
1665132 | kwl 4
1665146 | kwl 4
1665150 | kwl 4
1665152 | kwl 4
1665170 | kwl 4
1665172 | kwl 4
1665206 | kwl 8
1665210 | kwl 8
1665212 | kwl 8
1665342 | kwl 4
1665351 | kwl 4
1665365 | kwl 4
1665560 | kwl 4
1665570 | kwl 4
1665590 | kwl 4
1665631 | kwl 4
1665653 | kwl 4
1665702 | kwl 4
1665711 | kwl 4
1665782 | kwl 4
1665821 | kwl 4
1665833 | kwl 4
1665861 | kwl 4
1665933 | kwl 4
1665960 | kwl 4
1666096 | kwl 4
1666120 | kwl 4
1666128 | kwl 4
1666168 | kwl 4
1666200 | kwl 4
1666288 | kwl 4
1666298 | kwl 4
1666325 | kwl 4
1666335 | kwl 4
1666489 | kwl 4
1666495 | kwl 4
1666533 | kwl 4
1666555 | kwl 4
1666641 | kwl 4
1666981 | kwl 4
1667068 | kwl 4
1667082 | kwl 4
1667130 | kwl 4
1667243 | kwl 4
1667362 | kwl 4
1667406 | kwl 4
1667416 | kwl 4
1667426 | kwl 4
1667519 | kwl 4
1667527 | kwl 4
1667628 | kwl 4
1667741 | kwl 4
1667751 | kwl 4
1667798 | kwl 4
1667841 | kwl 4
1667851 | kwl 4
1667859 | kwl 4
1667921 | kwl 4
1667977 | kwl 4
1667995 | kwl 4
1668023 | kwl 4
1668030 | kwl 4
1668077 | kwl 4
1668091 | kwl 4
1668131 | kwl 4
1668147 | kwl 4
1668169 | kwl 4
1668178 | kwl 4
1668212 | kwl 4
1668228 | kwl 4
1668365 | kwl 4
1668388 | kwl 4
1668390 | kwl 4
1668404 | kwl 4
1668406 | kwl 4
1668429 | kwl 4
1668431 | kwl 4
1668485 | kwl 4
1668494 | kwl 4
1668518 | kwl 4
1668525 | kwl 4
1668588 | kwl 4
1668622 | kwl 4
1668633 | kwl 4
1668690 | kwl 4
1668699 | kwl 4
1668775 | kwl 4
1668783 | kwl 4
1668836 | kwl 4
1668922 | kwl 4
1668932 | kwl 4
1669021 | kwl 4
1669031 | kwl 4
1669047 | kwl 4
1669061 | kwl 4
1669084 | kwl 4
1669147 | kwl 4
1669156 | kwl 4
1669174 | kwl 4
1669183 | kwl 4
1669231 | kwl 4
1669239 | kwl 4
1669599 | kwl 4
1669623 | kwl 4
1669664 | kwl 4
1669768 | kwl 4
1669777 | kwl 4
1669781 | kwl 4
1670160 | kwl 4
1670168 | kwl 4
1670390 | kwl 4
1670763 | kwl 4
1670773 | kwl 4
1671049 | kwl 4
1671056 | kwl 4
1671063 | kwl 4
1671125 | kwl 4
1671204 | kwl 4
1671316 | kwl 4
1671420 | kwl 4
1671429 | kwl 4
1671440 | kwl 4
1671701 | kwl 4
1671709 | kwl 4
1671962 | kwl 4
1671969 | kwl 4
1671976 | kwl 4
1672078 | kwl 4
1672082 | kwl 4
1672590 | kwl 4
1672598 | kwl 4
1672606 | kwl 4
1672631 | kwl 4
1672638 | kwl 4
1672645 | kwl 4
1672681 | kwl 4
1672732 | kwl 4
1672754 | kwl 4
1672776 | kwl 4
1672779 | kwl 4
1673039 | kwl 4
1673054 | kwl 4
1673110 | kwl 4
1673113 | kwl 4
1673139 | kwl 4
1673155 | kwl 4
1673378 | kwl 4
1673769 | kwl 5
1673986 | kwl 4
1673994 | kwl 4
1674017 | kwl 4
1674503 | kwl 4
1674514 | kwl 4
1674521 | kwl 4
1674545 | kwl 4
1674558 | kwl 4
1674847 | kwl 3
1674904 | kwl 4
1674983 | kwl 4
1675014 | kwl 4
1675026 | kwl 4
1675043 | kwl 4
1715610 | kwl 4
1715617 | kwl 4
1715645 | kwl 4
1719184 | kwl 4
1719199 | kwl 4
1719312 | kwl 4
1719320 | kwl 4
1731081 | kwl 5
1731092 | kwl 5
1731129 | kwl 5
1731138 | kwl 5
1792953 | kwl 4
1817476 | kwl 4
1820130 | kwl 4
1820168 | kwl 4
1820170 | kwl 4
1820174 | kwl 4
1820176 | kwl 4
1820178 | kwl 4
1820180 | kwl 4
1820191 | kwl 4
1820193 | kwl 4
1820195 | kwl 4
1820197 | kwl 4
1820209 | kwl 4
1820222 | kwl 4
1820224 | kwl 4
1820226 | kwl 4
1820228 | kwl 4
1820239 | kwl 4
1820241 | kwl 4
1820243 | kwl 4
1820245 | kwl 4
1820247 | kwl 4
1820249 | kwl 4
1820989 | kwl 4
1820991 | kwl 4
1820993 | kwl 4
1820995 | kwl 4
1820997 | kwl 4
1820999 | kwl 4
1821001 | kwl 4
1821003 | kwl 4
1821005 | kwl 4
1821007 | kwl 4
1821009 | kwl 4
1821011 | kwl 4
1821029 | kwl 4
1821034 | kwl 4
1821039 | kwl 4
1821041 | kwl 4
1821047 | kwl 4
1821049 | kwl 4
1821051 | kwl 4

# IfcFlowSegment: Pipe Types:NLRS_50_PI_Mapress C-Staal (DN)_Geberit (105)
In: 00_Begane Grond
Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: NLRS_50_PI_Mapress C-Staal (DN)_Geberit
Name (Pipe Types:NLRS_50_PI_Mapress C-Staal (DN)_Geberit:...) | Group
1792892 | kwl 4
1800896 | cv-a 3
1801136 | cv-r 5
1801284 | cv-r 5
1801286 | cv-r 5
1801294 | cv-a 3
1801296 | cv-a 3
1801300 | cv-a 3
1801444 | cv-r 5
1801510 | cv-a 3
1801512 | cv-a 3
1801516 | cv-a 3
1801532 | cv-a 3
1801534 | cv-a 3
1801538 | cv-a 3
1801554 | cv-a 3
1801556 | cv-a 3
1801560 | cv-a 3
1801578 | cv-a 3
1801580 | cv-a 3
1801584 | cv-a 3
1801600 | cv-a 3
1801602 | cv-a 3
1801606 | cv-a 3
1801634 | cv-r 5
1801636 | cv-r 5
1801650 | cv-r 5
1801652 | cv-r 5
1801668 | cv-r 5
1801670 | cv-r 5
1801686 | cv-r 5
1801688 | cv-r 5
1801702 | cv-r 5
1801704 | cv-r 5
1801734 | cv-r 5
1801748 | cv-r 5
1801762 | cv-r 5
1803215 | cv-a 6
1803334 | cv-r 5
1803924 | cv-r 5
1803968 | cv-r 5
1804340 | cv-r 5
1804597 | cv-a 3
1804862 | cv-a 3
1805105 | cv-a 3
1805337 | cv-a 3
1805494 | cv-a 3
1805951 | cv-a 3
1806070 | cv-a 3
1806098 | cv-r 5
1806142 | cv-r 5
1806199 | cv-a 6
1806209 | cv-a 6
1806219 | cv-a 6
1806405 | cv-r 3
1806407 | cv-r 3
1806409 | cv-a 5
1806411 | cv-a 5
1806415 | cv-a 5
1806420 | cv-r 3
1806425 | cv-a 5
1806427 | cv-a 5
1806431 | cv-a 5
1806435 | cv-a 5
1806437 | cv-a 5
1806441 | cv-a 5
1806445 | cv-a 5
1806455 | cv-a 5
1806457 | cv-a 5
1806461 | cv-a 5
1806473 | cv-r 3
1806475 | cv-r 3
1806477 | cv-r 3
1806481 | cv-r 3
1806483 | cv-r 3
1806485 | cv-r 3
1806487 | cv-r 3
1806494 | cv-r 3
1806506 | cv-r 3
1806515 | cv-r 3
1806526 | cv-r 3
1806534 | cv-a 5
1806540 | cv-a 5
1806546 | cv-a 5
1806552 | cv-a 5
1806558 | cv-a 5
1806570 | cv-a 5
1806816 | cv-r 3
1806843 | cv-r 3
1806899 | cv-a 5
1806903 | cv-a 5
1807050 | cv-r 3
1807198 | cv-r 3
1807248 | cv-a 5
1807334 | cv-a 5
1807385 | cv-a 5
1807415 | cv-r 3
1807479 | cv-r 3
1807504 | cv-r 3
1807527 | cv-a 5
1807535 | cv-a 5
1817203 | gas 2
1817205 | gas 2
1817473 | kwl 4
1820533 | kwl 4

# IfcFlowSegment: Pipe Types:NLRS_50_PI_Mepla ML_Geberit (12)
In: 00_Begane Grond
Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: NLRS_50_PI_Mepla ML_Geberit
Group: kwl 4
Name (Pipe Types:NLRS_50_PI_Mepla ML_Geberit:...)
1660942
1660951
1660963
1661135
1661167
1661180
1661190
1661199
1661209
1661218
1661228
1661237

# IfcFlowSegment: Pipe Types:NLRS_52_PI_UN_PVC Wadal (OD)_Wavin (274)
Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: NLRS_52_PI_UN_PVC Wadal (OD)_Wavin
Name (Pipe Types:NLRS_52_PI_UN_PVC Wadal (OD)_Wavin:...) | In | Group
1478821 | 00_Begane Grond | vwa 1
1478950 | 00_Begane Grond
1479057 | 00_Begane Grond
1479091 | 00_Begane Grond | vwa 3
1479093 | 00_Begane Grond | vwa 3
1479099 | 00_Begane Grond
1479168 | 00_Begane Grond | vwa 4
1479174 | 00_Begane Grond
1482845 | 00_Begane Grond | vwa 1
1486288 | 00_Begane Grond | vwa 2
1486990 | 00_Begane Grond
1487092 | 00_Begane Grond | vwa 3
1487133 | 00_Begane Grond | vwa 3
1487143 | 00_Begane Grond | vwa 3
1487315 | 00_Begane Grond | vwa 3
1487480 | 00_Begane Grond | vwa 3
1543716 | 00_Begane Grond | vwa 5
1543722 | 00_Begane Grond
1544351 | -1_Kruipruimte
1544359 | -1_Kruipruimte | vwa 5
1544360 | -1_Kruipruimte | vwa 5
1544364 | -1_Kruipruimte
1544404 | -1_Kruipruimte | vwa 5
1544416 | -1_Kruipruimte | vwa 5
1544432 | -1_Kruipruimte | vwa 5
1544759 | -1_Kruipruimte | vwa 5
1544766 | -1_Kruipruimte
1544791 | -1_Kruipruimte | vwa 5
1545071 | -1_Kruipruimte | vwa 5
1545078 | -1_Kruipruimte
1545302 | -1_Kruipruimte | vwa 5
1545522 | -1_Kruipruimte
1546454 | -1_Kruipruimte | vwa 5
1546474 | -1_Kruipruimte | vwa 5
1546562 | -1_Kruipruimte | vwa 5
1546569 | -1_Kruipruimte
1546664 | -1_Kruipruimte | vwa 5
1546985 | -1_Kruipruimte | vwa 5
1546998 | -1_Kruipruimte
1547103 | -1_Kruipruimte | vwa 5
1547131 | -1_Kruipruimte | vwa 5
1547138 | -1_Kruipruimte
1547241 | -1_Kruipruimte | vwa 5
1547347 | -1_Kruipruimte | vwa 5
1547356 | -1_Kruipruimte
1547397 | -1_Kruipruimte | vwa 5
1547542 | -1_Kruipruimte | vwa 5
1547552 | -1_Kruipruimte | vwa 5
1547574 | -1_Kruipruimte | vwa 5
1547766 | -1_Kruipruimte | vwa 5
1547777 | -1_Kruipruimte
1547811 | -1_Kruipruimte | vwa 5
1547841 | -1_Kruipruimte | vwa 5
1547952 | -1_Kruipruimte | vwa 5
1547959 | -1_Kruipruimte
1547993 | -1_Kruipruimte | vwa 5
1548023 | -1_Kruipruimte | vwa 5
1548385 | -1_Kruipruimte | ontl 1
1548699 | -1_Kruipruimte | vwa 5
1548706 | -1_Kruipruimte
1548944 | -1_Kruipruimte | vwa 5
1549428 | -1_Kruipruimte | vwa 5
1549437 | -1_Kruipruimte
1549505 | -1_Kruipruimte | vwa 5
1549651 | -1_Kruipruimte | ontl 1
1549767 | -1_Kruipruimte | vwa 5
1549776 | -1_Kruipruimte
1549928 | -1_Kruipruimte
1549996 | -1_Kruipruimte | vwa 5
1550021 | -1_Kruipruimte | vwa 5
1550254 | -1_Kruipruimte | vwa 5
1550305 | -1_Kruipruimte | vwa 5
1550341 | -1_Kruipruimte | vwa 5
1550625 | -1_Kruipruimte | vwa 5
1550634 | -1_Kruipruimte
1550850 | -1_Kruipruimte | vwa 5
1551401 | -1_Kruipruimte | vwa 5
1551617 | -1_Kruipruimte | vwa 5
1551626 | -1_Kruipruimte
1551676 | -1_Kruipruimte | vwa 5
1551798 | -1_Kruipruimte | vwa 5
1552054 | -1_Kruipruimte | vwa 5
1552063 | -1_Kruipruimte
1552334 | -1_Kruipruimte | vwa 5
1552348 | -1_Kruipruimte | vwa 5
1552371 | -1_Kruipruimte | vwa 5
1552604 | -1_Kruipruimte | vwa 5
1552615 | -1_Kruipruimte
1552737 | -1_Kruipruimte | vwa 5
1552764 | -1_Kruipruimte | vwa 5
1552806 | -1_Kruipruimte
1552922 | -1_Kruipruimte | vwa 5
1552948 | -1_Kruipruimte | vwa 5
1552957 | -1_Kruipruimte | vwa 5
1553029 | -1_Kruipruimte | vwa 5
1553112 | -1_Kruipruimte | vwa 5
1553121 | -1_Kruipruimte
1553245 | -1_Kruipruimte | vwa 5
1553286 | -1_Kruipruimte | vwa 5
1553405 | -1_Kruipruimte | vwa 5
1553465 | -1_Kruipruimte
1553624 | -1_Kruipruimte | vwa 5
1553819 | -1_Kruipruimte | vwa 5
1553834 | -1_Kruipruimte
1553862 | -1_Kruipruimte | vwa 5
1553869 | -1_Kruipruimte
1553964 | -1_Kruipruimte | vwa 5
1553971 | -1_Kruipruimte
1554109 | -1_Kruipruimte | vwa 5
1554143 | -1_Kruipruimte | vwa 5
1554173 | -1_Kruipruimte | vwa 5
1554769 | -1_Kruipruimte | vwa 5
1554877 | -1_Kruipruimte
1554955 | -1_Kruipruimte | vwa 5
1555466 | -1_Kruipruimte
1555478 | -1_Kruipruimte | vwa 3
1555516 | -1_Kruipruimte | vwa 3
1555722 | -1_Kruipruimte | vwa 2
1555771 | -1_Kruipruimte | vwa 2
1555907 | -1_Kruipruimte | vwa 2
1556008 | -1_Kruipruimte | vwa 2
1556546 | -1_Kruipruimte | vwa 2
1556588 | -1_Kruipruimte
1556602 | -1_Kruipruimte | vwa 2
1556721 | -1_Kruipruimte
1556805 | -1_Kruipruimte | vwa 2
1557001 | -1_Kruipruimte | vwa 2
1557009 | -1_Kruipruimte | vwa 2
1557022 | -1_Kruipruimte | vwa 2
1557177 | -1_Kruipruimte | vwa 2
1557186 | -1_Kruipruimte | vwa 2
1557250 | -1_Kruipruimte | vwa 2
1558575 | -1_Kruipruimte | ontl 2
1558583 | -1_Kruipruimte | ontl 2
1558618 | -1_Kruipruimte | ontl 2
1558764 | -1_Kruipruimte | ontl 1
1558962 | -1_Kruipruimte | ontl 1
1559054 | -1_Kruipruimte | ontl 1
1559057 | -1_Kruipruimte | ontl 1
1559709 | -1_Kruipruimte | hwa 1
1559915 | -1_Kruipruimte | hwa 1
1559960 | -1_Kruipruimte | hwa 1
1560003 | -1_Kruipruimte | hwa 1
1560016 | -1_Kruipruimte | hwa 1
1560029 | -1_Kruipruimte | hwa 1
1560042 | -1_Kruipruimte | hwa 1
1560053 | -1_Kruipruimte | hwa 1
1560064 | -1_Kruipruimte | hwa 1
1560077 | -1_Kruipruimte | hwa 1
1560090 | -1_Kruipruimte | hwa 1
1560114 | -1_Kruipruimte | hwa 7
1560125 | -1_Kruipruimte | hwa 7
1560204 | -1_Kruipruimte | hwa 1
1560221 | -1_Kruipruimte | hwa 1
1560325 | -1_Kruipruimte | hwa 1
1560336 | -1_Kruipruimte | hwa 1
1560347 | -1_Kruipruimte | hwa 1
1560360 | -1_Kruipruimte | hwa 1
1560371 | -1_Kruipruimte | hwa 1
1560384 | -1_Kruipruimte | hwa 1
1560395 | -1_Kruipruimte | hwa 1
1560406 | -1_Kruipruimte | hwa 1
1560417 | -1_Kruipruimte | hwa 1
1560428 | -1_Kruipruimte | hwa 1
1560439 | -1_Kruipruimte | hwa 1
1560463 | -1_Kruipruimte | hwa 7
1560476 | -1_Kruipruimte | hwa 7
1560511 | -1_Kruipruimte
1560532 | -1_Kruipruimte | hwa 1
1560563 | -1_Kruipruimte
1560581 | -1_Kruipruimte
1560587 | -1_Kruipruimte
1560593 | -1_Kruipruimte
1560599 | -1_Kruipruimte
1560605 | -1_Kruipruimte
1560611 | -1_Kruipruimte
1560617 | -1_Kruipruimte
1560623 | -1_Kruipruimte
1560629 | -1_Kruipruimte
1560635 | -1_Kruipruimte
1560687 | -1_Kruipruimte
1561456 | -1_Kruipruimte | hwa 2
1561485 | -1_Kruipruimte | hwa 2
1561510 | -1_Kruipruimte | hwa 2
1561533 | -1_Kruipruimte | hwa 2
1561600 | -1_Kruipruimte | hwa 2
1561689 | -1_Kruipruimte | hwa 2
1561763 | -1_Kruipruimte | hwa 2
1561778 | -1_Kruipruimte | hwa 2
1561789 | -1_Kruipruimte | hwa 2
1561882 | -1_Kruipruimte | hwa 2
1561892 | -1_Kruipruimte
1561922 | -1_Kruipruimte | hwa 2
1561930 | -1_Kruipruimte | hwa 2
1562001 | -1_Kruipruimte | hwa 2
1562016 | -1_Kruipruimte | hwa 2
1562027 | -1_Kruipruimte | hwa 2
1562042 | -1_Kruipruimte | hwa 2
1562053 | -1_Kruipruimte | hwa 2
1562070 | -1_Kruipruimte | hwa 2
1562085 | -1_Kruipruimte | hwa 2
1562096 | -1_Kruipruimte | hwa 2
1562309 | -1_Kruipruimte
1562364 | -1_Kruipruimte
1562394 | -1_Kruipruimte
1562428 | -1_Kruipruimte | hwa 2
1562478 | -1_Kruipruimte
1562585 | -1_Kruipruimte
1562664 | -1_Kruipruimte
1563307 | -1_Kruipruimte
1563377 | -1_Kruipruimte
1563392 | -1_Kruipruimte
1563440 | -1_Kruipruimte
1713030 | -1_Kruipruimte | vwa 5
1713297 | -1_Kruipruimte | vwa 5
1713351 | -1_Kruipruimte | vwa 5
1713958 | -1_Kruipruimte | vwa 5
1713967 | -1_Kruipruimte
1714059 | -1_Kruipruimte | vwa 5
1714158 | -1_Kruipruimte
1714919 | -1_Kruipruimte | vwa 5
1714928 | -1_Kruipruimte
1715035 | -1_Kruipruimte | vwa 5
1715175 | -1_Kruipruimte
1715310 | -1_Kruipruimte | vwa 5
1715318 | -1_Kruipruimte | vwa 5
1715455 | -1_Kruipruimte | vwa 1
1715500 | -1_Kruipruimte | vwa 1
1715794 | 00_Begane Grond | hwa 1
1715808 | 00_Begane Grond | hwa 1
1715928 | 00_Begane Grond | hwa 1
1716017 | 00_Begane Grond | hwa 1
1716021 | 00_Begane Grond | hwa 1
1716025 | 00_Begane Grond | hwa 1
1717056 | -1_Kruipruimte | hwa 1
1717122 | -1_Kruipruimte
1717366 | -1_Kruipruimte
1717394 | -1_Kruipruimte | hwa 1
1717405 | -1_Kruipruimte | hwa 1
1717567 | -1_Kruipruimte | hwa 1
1717571 | -1_Kruipruimte
1717573 | -1_Kruipruimte | hwa 1
1717576 | -1_Kruipruimte | hwa 1
1718323 | -1_Kruipruimte
1718331 | -1_Kruipruimte
1718881 | -1_Kruipruimte | vwa 1
1793168 | 00_Begane Grond | vwa 6
1793176 | 00_Begane Grond | vwa 6
1793202 | 00_Begane Grond | vwa 6
1793238 | 00_Begane Grond | vwa 6
1793280 | 00_Begane Grond
1793314 | 00_Begane Grond | vwa 6
1793585 | 00_Begane Grond | vwa 6
1793691 | 00_Begane Grond | vwa 6
1793746 | 00_Begane Grond | vwa 6
1793873 | 00_Begane Grond
1794132 | 00_Begane Grond | vwa 7
1794172 | 00_Begane Grond | vwa 7
1818094 | 00_Begane Grond | vwa 8
1818096 | 00_Begane Grond | vwa 8
1818376 | 00_Begane Grond | vwa 9
1818378 | 00_Begane Grond | vwa 9
1818390 | 00_Begane Grond | vwa 10
1818392 | 00_Begane Grond | vwa 10
1818406 | 00_Begane Grond | vwa 11
1818408 | 00_Begane Grond | vwa 11
1818558 | 00_Begane Grond | vwa 12
1818568 | 00_Begane Grond | vwa 12
1818606 | 00_Begane Grond | vwa 12
1818690 | 00_Begane Grond | vwa 13
1818692 | 00_Begane Grond | vwa 13
1818696 | 00_Begane Grond | vwa 13
1818758 | 00_Begane Grond
1818775 | 00_Begane Grond

# IfcFlowSegment: Pipe Types:Vlampijp T-stuk (186)
Pset_DistributionFlowElementCommon - Reference: Vlampijp T-stuk
Name (Pipe Types:Vlampijp T-stuk:...) | In | Group
1344857 | -1_Kruipruimte | kwl 1
1344896 | -1_Kruipruimte | kwl 2
1643108 | 00_Begane Grond | cv-a 1
1643123 | 00_Begane Grond | cv-r 1
1643413 | 00_Begane Grond | cv-a 1
1643483 | 00_Begane Grond | cv-a 1
1643529 | 00_Begane Grond | cv-a 1
1643609 | 00_Begane Grond | cv-r 1
1643617 | 00_Begane Grond | cv-r 1
1643653 | 00_Begane Grond | cv-r 1
1645033 | 00_Begane Grond | cv-r 1
1645070 | 00_Begane Grond | cv-a 1
1645097 | 00_Begane Grond | cv-a 1
1645198 | 00_Begane Grond | cv-r 1
1645208 | 00_Begane Grond | cv-r 1
1645233 | 00_Begane Grond | cv-a 1
1645243 | 00_Begane Grond | cv-a 1
1645322 | 00_Begane Grond | cv-r 1
1645360 | 00_Begane Grond | cv-a 1
1645657 | 00_Begane Grond | cv-r 1
1645768 | 00_Begane Grond | cv-r 1
1646012 | 00_Begane Grond | cv-r 1
1646744 | 00_Begane Grond | cv-r 1
1646775 | 00_Begane Grond | cv-r 1
1646954 | 00_Begane Grond | cv-r 1
1646971 | 00_Begane Grond | cv-a 4
1646990 | 00_Begane Grond | cv-r 1
1647009 | 00_Begane Grond | cv-a 4
1647097 | 00_Begane Grond | cv-a 4
1647129 | 00_Begane Grond | cv-a 4
1648237 | 00_Begane Grond | cv-r 1
1648249 | 00_Begane Grond | cv-r 1
1648280 | 00_Begane Grond | cv-r 1
1648290 | 00_Begane Grond | cv-r 1
1648355 | 00_Begane Grond | cv-a 4
1648361 | 00_Begane Grond | cv-a 4
1648469 | 00_Begane Grond | cv-a 4
1648554 | 00_Begane Grond | cv-a 4
1648590 | 00_Begane Grond | cv-a 4
1648604 | 00_Begane Grond | cv-a 4
1648620 | 00_Begane Grond | cv-r 1
1648627 | 00_Begane Grond | cv-r 1
1648739 | 00_Begane Grond | cv-a 4
1648742 | 00_Begane Grond | cv-a 4
1648750 | 00_Begane Grond | cv-r 1
1648753 | 00_Begane Grond | cv-r 1
1648768 | 00_Begane Grond | cv-r 1
1648783 | 00_Begane Grond | cv-r 1
1648824 | 00_Begane Grond | cv-a 4
1648834 | 00_Begane Grond | cv-a 4
1648984 | 00_Begane Grond | cv-a 4
1649052 | 00_Begane Grond | cv-r 1
1649123 | 00_Begane Grond | cv-a 4
1649169 | 00_Begane Grond | cv-r 1
1649179 | 00_Begane Grond | cv-r 1
1649225 | 00_Begane Grond | cv-a 4
1649235 | 00_Begane Grond | cv-a 4
1649431 | 00_Begane Grond | cv-a 4
1649471 | 00_Begane Grond | cv-a 4
1649589 | 00_Begane Grond | cv-r 1
1649623 | 00_Begane Grond | cv-r 1
1649631 | 00_Begane Grond | cv-r 1
1649726 | 00_Begane Grond | cv-a 4
1649965 | 00_Begane Grond | cv-a 4
1652305 | 00_Begane Grond | cv-r 1
1652316 | 00_Begane Grond | cv-a 4
1652689 | 00_Begane Grond | cv-a 4
1652713 | 00_Begane Grond | cv-r 1
1652735 | 00_Begane Grond | cv-a 4
1652831 | 00_Begane Grond | cv-r 1
1652841 | 00_Begane Grond | cv-r 1
1652872 | 00_Begane Grond | cv-r 1
1652907 | 00_Begane Grond | cv-a 4
1653052 | 00_Begane Grond | cv-a 4
1653113 | 00_Begane Grond | cv-r 1
1653123 | 00_Begane Grond | cv-r 1
1653152 | 00_Begane Grond | cv-a 4
1653162 | 00_Begane Grond | cv-a 4
1653291 | 00_Begane Grond | cv-r 1
1653300 | 00_Begane Grond | cv-r 1
1653528 | 00_Begane Grond | cv-r 1
1653752 | 00_Begane Grond | cv-r 1
1653794 | 00_Begane Grond | cv-r 1
1653823 | 00_Begane Grond | cv-r 1
1653854 | 00_Begane Grond | cv-a 4
1653862 | 00_Begane Grond | cv-a 4
1653885 | 00_Begane Grond | cv-a 4
1653895 | 00_Begane Grond | cv-a 4
1654070 | 00_Begane Grond | cv-a 4
1654093 | 00_Begane Grond | cv-r 1
1654171 | 00_Begane Grond | cv-a 4
1654201 | 00_Begane Grond | cv-r 1
1654268 | 00_Begane Grond | cv-r 1
1654469 | 00_Begane Grond | cv-r 1
1654499 | 00_Begane Grond | cv-a 4
1654511 | 00_Begane Grond | cv-a 4
1654637 | 00_Begane Grond | cv-r 1
1654681 | 00_Begane Grond | cv-a 4
1655015 | 00_Begane Grond | cv-r 1
1655018 | 00_Begane Grond | cv-r 1
1655027 | 00_Begane Grond | cv-a 4
1655030 | 00_Begane Grond | cv-a 4
1655059 | 00_Begane Grond | cv-r 1
1655067 | 00_Begane Grond | cv-r 1
1655096 | 00_Begane Grond | cv-a 4
1655104 | 00_Begane Grond | cv-a 4
1655171 | 00_Begane Grond | cv-a 4
1655193 | 00_Begane Grond | cv-r 1
1655281 | 00_Begane Grond | cv-r 1
1655375 | 00_Begane Grond | cv-r 1
1655424 | 00_Begane Grond | cv-r 1
1655472 | 00_Begane Grond | cv-r 1
1655591 | 00_Begane Grond | cv-r 1
1655655 | 00_Begane Grond | cv-a 4
1655883 | 00_Begane Grond | cv-a 4
1655891 | 00_Begane Grond | cv-a 4
1655952 | 00_Begane Grond | cv-a 4
1655960 | 00_Begane Grond | cv-a 4
1656111 | 00_Begane Grond | cv-a 4
1656135 | 00_Begane Grond | cv-r 1
1656333 | 00_Begane Grond | cv-a 4
1656429 | 00_Begane Grond | cv-r 1
1659256 | 00_Begane Grond | cv-a 4
1660056 | 00_Begane Grond | cv-r 1
1660103 | 00_Begane Grond | cv-r 1
1660111 | 00_Begane Grond | cv-r 1
1660137 | 00_Begane Grond | cv-a 4
1660143 | 00_Begane Grond | cv-a 4
1660195 | 00_Begane Grond | cv-r 1
1660220 | 00_Begane Grond | cv-a 4
1660326 | 00_Begane Grond | cv-a 4
1660334 | 00_Begane Grond | cv-a 4
1660342 | 00_Begane Grond | cv-a 4
1660381 | 00_Begane Grond | cv-a 4
1660431 | 00_Begane Grond | cv-r 1
1660439 | 00_Begane Grond | cv-r 1
1660447 | 00_Begane Grond | cv-r 1
1660468 | 00_Begane Grond | cv-r 1
1660670 | 00_Begane Grond | cv-a 4
1660676 | 00_Begane Grond | cv-a 4
1660696 | 00_Begane Grond | cv-r 1
1660700 | 00_Begane Grond | cv-r 1
1660712 | 00_Begane Grond | cv-r 1
1660719 | 00_Begane Grond | cv-r 1
1660742 | 00_Begane Grond | cv-a 4
1660751 | 00_Begane Grond | cv-a 4
1660785 | 00_Begane Grond | cv-a 4
1660797 | 00_Begane Grond | cv-a 4
1660842 | 00_Begane Grond | cv-r 1
1666943 | 00_Begane Grond | cv-a 4
1766678 | 00_Begane Grond | cv-a 4
1766915 | 00_Begane Grond | cv-r 1
1766923 | 00_Begane Grond | cv-r 1
1767107 | 00_Begane Grond | cv-r 1
1767116 | 00_Begane Grond | cv-r 1
1767119 | 00_Begane Grond | cv-r 1
1767132 | 00_Begane Grond | cv-r 1
1767181 | 00_Begane Grond | cv-a 4
1767219 | 00_Begane Grond | cv-a 4
1767309 | 00_Begane Grond | cv-a 4
1767315 | 00_Begane Grond | cv-a 4
1767623 | 00_Begane Grond | cv-a 4
1767688 | 00_Begane Grond | cv-a 4
1767698 | 00_Begane Grond | cv-a 4
1767706 | 00_Begane Grond | cv-a 4
1767822 | 00_Begane Grond | cv-r 1
1767891 | 00_Begane Grond | cv-r 1
1768032 | 00_Begane Grond | cv-r 1
1768089 | 00_Begane Grond | cv-r 1
1768120 | 00_Begane Grond | cv-a 4
1768146 | 00_Begane Grond | cv-a 4
1768325 | 00_Begane Grond | cv-a 4
1768447 | 00_Begane Grond | cv-a 4
1768486 | 00_Begane Grond | cv-a 4
1768703 | 00_Begane Grond | cv-r 1
1768715 | 00_Begane Grond | cv-r 1
1768838 | 00_Begane Grond | cv-r 1
1768847 | 00_Begane Grond | cv-r 1
1768872 | 00_Begane Grond | cv-a 4
1768881 | 00_Begane Grond | cv-a 4
1768972 | 00_Begane Grond | cv-a 4
1769001 | 00_Begane Grond | cv-r 1
1769080 | 00_Begane Grond | cv-a 4
1769107 | 00_Begane Grond | cv-r 1
1769233 | 00_Begane Grond | cv-r 1
1769290 | 00_Begane Grond | cv-a 4

# IfcFlowSegment: Pipe Types:Vlampijp tap (26)
In: 00_Begane Grond
Pset_DistributionFlowElementCommon - Reference: Vlampijp tap
Name (Pipe Types:Vlampijp tap:...) | Group
1644072 | cv-r 1
1644077 | cv-r 1
1644080 | cv-r 1
1644084 | cv-a 4
1644089 | cv-a 4
1644092 | cv-a 4
1644096 | cv-r 1
1644102 | cv-a 4
1644108 | cv-r 1
1644110 | cv-a 4
1644112 | cv-r 1
1644114 | cv-a 4
1644163 | cv-r 1
1644167 | cv-a 1
1644176 | cv-a 4
1644178 | cv-a 4
1644186 | cv-a 4
1644188 | cv-a 4
1644192 | cv-a 4
1644196 | cv-a 4
1644200 | cv-r 1
1644202 | cv-a 4
1644769 | cv-a 4
1644823 | cv-a 4
1645701 | cv-a 1
1645983 | cv-r 1

# IfcFlowSegment: Rectangular Duct:verzinkt staal (T-stuk) (34)
In: 00_Begane Grond
Type - PredefinedType: RIGIDSEGMENT
Classification: 3A(57.55.21) (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt staal (T-stuk)
Name (Rectangular Duct:verzinkt staal (T-stuk):...) | Group
1581417 | lu-r 6
1591979 | lu-r 1
1592453 | lu-r 1
1611908 | lu-r 3
1612219 | lu-r 3
1613148 | lu-t 4
1613184 | lu-t 4
1613235 | lu-t 4
1614432 | lu-t 4
1614614 | lu-t 4
1614751 | lu-t 4
1615837 | lu-t 4
1616118 | lu-t 4
1616264 | lu-t 4
1616611 | lu-t 4
1617194 | lu-t 4
1617291 | lu-t 4
1617357 | lu-t 4
1617438 | lu-t 4
1617543 | lu-t 4
1617645 | lu-t 4
1688339 | lu-t 2
1688350 | lu-t 2
1688437 | lu-t 2
1688449 | lu-t 2
1693730 | lu-t 2
1750097 | lu-t 2
1750246
1751056 | afb 6
1751873 | lu-t 2
1753195 | lu-t 2
1753628 | lu-t 2
1754418 | lu-t 2
1754554 | lu-t 2

# IfcFlowSegment: Rectangular Duct:verzinkt staal (zadel) (19)
In: 00_Begane Grond
Type - PredefinedType: RIGIDSEGMENT
Classification: 3A(57.55.21) (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt staal (zadel)
Name (Rectangular Duct:verzinkt staal (zadel):...) | Group
1601221 | lu-r 2
1602208 | lu-r 8
1602238 | lu-r 10
1602253 | lu-r 11
1606822 | lu-r 12
1608427 | bla 6
1608616 | bla 6
1608666 | afb 5
1610581 | bla 5
1610584 | afb 4
1748942 | afb 4
1749193
1749336 | bla 5
1758315 | bla 4
1758613 | afb 6
1760552 | bla 4
1765779 | bla 4
1766305 | afb 6
1766459 | afb 6

# IfcFlowSegment: Round Duct:verzinkt staal ( zadel ● - █ )_Luka (14)
In: 00_Begane Grond
Type - PredefinedType: RIGIDSEGMENT
Classification: 3A(57.55.21) (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt staal ( zadel ● - █ )_Luka
Name (Round Duct:verzinkt staal ( zadel ● - █ )_Luka:...) | Group
1607328 | lu-r 12
1688214 | lu-t 2
1723915 | bla 6
1752669 | lu-t 9
1754746 | lu-t 9
1754756 | lu-t 9
1754940 | lu-t 9
1755511 | lu-t 9
1756327 | lu-t 9
1756442 | lu-t 9
1756655 | lu-t 9
1756680 | lu-t 9
1757065 | lu-t 9
1757075 | lu-t 9

# IfcFlowSegment: Round Duct:verzinkt staal (T-stuk)_Luka (336)
In: 00_Begane Grond
Type - PredefinedType: RIGIDSEGMENT
Classification: 3A(57.55.21) (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: verzinkt staal (T-stuk)_Luka
Name (Round Duct:verzinkt staal (T-stuk)_Luka:...) | Group
1500865 | lu-t 3
1563851 | lu-t 2
1565078 | lu-t 2
1572922 | lu-t 2
1587064 | lu-r 1
1587078 | lu-r 1
1587258 | lu-r 1
1587274 | lu-r 1
1587343 | lu-r 1
1587518 | lu-r 1
1587713 | lu-r 1
1587716 | lu-r 1
1587718 | lu-r 1
1587727 | lu-r 1
1587732 | lu-r 1
1587744 | lu-r 1
1587761 | lu-r 1
1588076 | lu-r 1
1588100 | lu-r 1
1588116 | lu-r 1
1588254 | lu-r 1
1588257 | lu-r 1
1588261 | lu-r 1
1588265 | lu-r 1
1588268 | lu-r 1
1588270 | lu-r 1
1588274 | lu-r 1
1588276 | lu-r 1
1588279 | lu-r 1
1588283 | lu-r 1
1588304 | lu-r 1
1588351 | lu-r 1
1588354 | lu-r 1
1588378 | lu-r 1
1588422 | lu-r 1
1588425 | lu-r 1
1588452 | lu-r 1
1588455 | lu-r 1
1588478 | lu-r 1
1588481 | lu-r 1
1588513 | lu-r 1
1588518 | lu-r 1
1588535 | lu-r 1
1588561 | lu-r 1
1588564 | lu-r 1
1588580 | lu-r 1
1588583 | lu-r 1
1588646 | lu-r 1
1588672 | lu-r 1
1588794 | lu-r 1
1588822 | lu-r 1
1588850 | lu-r 1
1588882 | lu-r 1
1589173 | lu-r 1
1589319 | lu-r 1
1589366 | lu-r 1
1589444 | lu-r 1
1589498 | lu-r 1
1589543 | lu-r 1
1589602 | lu-r 1
1589952 | lu-r 1
1589954 | lu-r 1
1590157 | lu-r 1
1590335 | lu-r 1
1590337 | lu-r 1
1590343 | lu-r 1
1590362 | lu-r 1
1590364 | lu-r 1
1590370 | lu-r 1
1590383 | lu-r 1
1590385 | lu-r 1
1590391 | lu-r 1
1590404 | lu-r 1
1590406 | lu-r 1
1590412 | lu-r 1
1590429 | lu-r 1
1590434 | lu-r 1
1590439 | lu-r 1
1590454 | lu-r 1
1590469 | lu-r 1
1591259 | lu-r 1
1591659 | lu-r 1
1591661 | lu-r 1
1591715 | lu-r 1
1591742 | lu-r 1
1591744 | lu-r 1
1591772 | lu-r 1
1591782 | lu-r 1
1591793 | lu-r 1
1591924 | lu-r 1
1592384 | lu-r 1
1592673 | lu-r 1
1592802 | lu-r 1
1592858 | lu-r 1
1592919 | lu-r 1
1592963 | lu-r 1
1593196 | lu-r 1
1593277 | lu-r 1
1593390 | lu-r 1
1594049 | lu-t 1
1594235 | lu-t 1
1594407 | lu-t 1
1594424 | lu-t 1
1594788 | lu-r 1
1595074 | lu-r 1
1595076 | lu-r 1
1595080 | lu-r 1
1595082 | lu-r 1
1595084 | lu-r 1
1595086 | lu-r 1
1595241 | lu-r 1
1595517 | lu-r 1
1595571 | lu-r 1
1596133 | lu-t 1
1596777 | lu-t 1
1596872 | lu-t 1
1596927 | lu-t 1
1597267 | lu-t 1
1597581 | lu-t 1
1597866 | lu-t 1
1598226 | lu-t 1
1598576 | lu-r 1
1598676 | lu-t 1
1598754 | lu-t 1
1598774 | lu-t 1
1598788 | lu-t 1
1603398 | lu-r 1
1603410 | lu-r 1
1603475 | lu-t 1
1603845 | lu-t 3
1604341 | lu-t 3
1604358 | lu-t 3
1605215 | lu-t 3
1605221 | lu-t 3
1605223 | lu-t 3
1605225 | lu-t 3
1605242 | lu-t 3
1605245 | lu-t 3
1605251 | lu-t 3
1605360 | lu-t 3
1605665 | lu-t 3
1605816 | lu-t 3
1605824 | lu-t 3
1606170 | lu-t 3
1606173 | lu-t 3
1606178 | lu-t 3
1606187 | lu-t 3
1606190 | lu-t 3
1606193 | lu-t 3
1606205 | lu-t 3
1606630 | lu-t 3
1609215 | afb 5
1609382 | afb 5
1621185 | lu-r 4
1623026 | lu-r 4
1623034 | lu-r 4
1623226 | lu-r 4
1623335 | lu-r 4
1623345 | lu-r 4
1623406 | lu-r 4
1623418 | lu-r 4
1623604 | lu-r 4
1623650 | lu-r 4
1623683 | lu-r 4
1623781 | lu-r 4
1624973 | lu-r 4
1626627 | lu-t 6
1626633 | lu-t 6
1626675 | lu-t 6
1626691 | lu-t 6
1626694 | lu-t 6
1626696 | lu-t 6
1627213 | lu-t 6
1627216 | lu-t 6
1627417 | lu-t 6
1627769 | lu-t 6
1627778 | lu-t 6
1627805 | lu-t 6
1627813 | lu-t 6
1627845 | lu-t 6
1627857 | lu-t 6
1627918 | lu-t 6
1627926 | lu-t 6
1628302 | lu-r 4
1628407 | lu-r 4
1628415 | lu-r 4
1628422 | lu-r 4
1628687 | lu-r 4
1628695 | lu-r 4
1628817 | lu-r 4
1628901 | lu-r 4
1628917 | lu-r 4
1628954 | lu-r 4
1629015 | lu-r 4
1629033 | lu-r 4
1629151 | lu-r 4
1629283 | lu-r 4
1629299 | lu-r 4
1629384 | lu-r 4
1630259 | lu-r 4
1630482 | afb 3
1631574 | lu-r 4
1632310 | lu-t 6
1632312 | lu-t 6
1632337 | lu-r 4
1632386 | lu-r 4
1632388 | lu-r 4
1632536 | lu-t 6
1633156 | lu-r 4
1633324 | lu-t 6
1633390 | lu-r 4
1638233 | lu-t 6
1638297 | lu-t 6
1638362 | lu-r 4
1638463 | lu-t 6
1638601 | lu-t 6
1639201 | lu-r 4
1639218 | lu-r 4
1639269 | lu-r 4
1646182 | lu-t 6
1646365 | lu-t 6
1646388 | lu-r 4
1684215 | lu-t 1
1684420 | lu-t 1
1684468 | lu-r 1
1684507 | lu-t 1
1684550 | lu-r 1
1711565 | lu-t 1
1711864 | bla 6
1711886 | bla 6
1722662 | afb 3
1722806 | afb 3
1722904 | afb 3
1722910 | afb 3
1723083 | afb 5
1723478 | afb 5
1723486 | afb 5
1723913 | bla 6
1723944 | bla 6
1724039 | bla 6
1724135 | afb 5
1724298 | afb 5
1724613 | afb 5
1731609 | afb 3
1731665 | afb 3
1741978 | lu-t 3
1742633 | lu-t 3
1743137 | lu-t 3
1743299 | lu-t 3
1743334 | lu-t 3
1743444 | lu-t 3
1743451 | lu-t 3
1743525 | lu-t 3
1743739 | lu-t 3
1744001 | lu-t 3
1744121 | lu-t 3
1770245 | lu-t 3
1770488 | lu-t 3
1786433 | lu-r 7
1786729 | lu-r 7
1786766 | lu-r 7
1786778 | lu-r 7
1786815 | lu-r 7
1786872 | lu-r 7
1786883 | lu-r 7
1786958 | lu-r 7
1786967 | lu-r 7
1786976 | lu-r 7
1787439 | lu-r 7
1787567 | lu-r 7
1787636 | lu-r 7
1787665 | lu-r 7
1791199 | lu-r 7
1791212 | lu-r 7
1791251 | lu-r 7
1794242 | afb 1
1794251 | afb 1
1794300 | lu-r 7
1794314 | lu-r 7
1794344 | lu-r 7
1794358 | lu-r 7
1794364 | lu-r 7
1795516 | lu-r 7
1795532 | lu-r 7
1795536 | lu-r 7
1796541 | lu-r 7
1796626 | lu-r 7
1796714 | lu-r 7
1796750 | lu-r 7
1796855 | lu-r 7
1797083 | lu-r 7
1799274 | afb 7
1799281 | afb 7
1813765 | lu-r 9
1813779 | lu-r 9
1813786 | lu-r 9
1813797 | lu-r 9
1813897 | lu-r 9
1814002 | lu-r 9
1814011 | lu-r 9
1814022 | lu-r 9
1814040 | lu-r 9
1814047 | lu-r 9
1814054 | lu-r 9
1814548 | lu-r 9
1814558 | lu-r 9
1814580 | lu-r 9
1814602 | lu-r 9
1814611 | lu-r 9
1814820 | lu-r 9
1814829 | lu-r 9
1814843 | lu-r 9
1814850 | lu-r 9
1816132 | lu-r 9
1816143 | lu-r 9
1816156 | lu-r 9
1816219 | lu-r 9
1816230 | lu-r 9
1816252 | lu-r 9
1816263 | lu-r 9
1816315 | lu-r 9
1816324 | lu-r 9
1816370 | lu-r 9
1816398 | lu-r 9
1816534 | lu-r 9
1816833 | lu-r 9
1816845 | lu-r 9
1816857 | lu-r 9
1816883 | lu-r 9
1816915 | lu-r 9
1816974 | lu-r 9
1816986 | lu-r 9
1816998 | lu-r 9
1817021 | lu-r 9
1817053 | lu-r 9
1817062 | lu-r 9

# IfcFlowTerminal: 125 (48)
In: 00_Begane Grond
Type - Description: RRVO; PredefinedType: GRILLE; Material: 57_Ral_9010
Pset_ManufacturerTypeInformation - Manufacturer: Solid Air
Pset_DistributionFlowElementCommon - Reference: 125
Name (NLRS_57_AIR_UN_Solid Air_RRVO:125:...) | Group
1586234 | lu-r 1
1586254 | lu-r 1
1586346 | lu-r 1
1586875 | lu-r 1
1587897 | lu-r 1
1588002 | lu-r 1
1588289 | lu-r 1
1588290 | lu-r 1
1588934 | lu-r 1
1588957 | lu-r 1
1588984 | lu-r 1
1589005 | lu-r 1
1589257 | lu-r 1
1589958 | lu-r 1
1590341 | lu-r 1
1590368 | lu-r 1
1590389 | lu-r 1
1590410 | lu-r 1
1591665 | lu-r 1
1591748 | lu-r 1
1593086 | lu-r 1
1593145 | lu-r 1
1628508 | lu-r 4
1629980 | lu-r 4
1790997 | lu-r 7
1791064 | lu-r 7
1791119 | lu-r 7
1791319 | lu-r 7
1791361 | lu-r 7
1795043 | lu-r 7
1795052 | lu-r 7
1795606 | lu-r 7
1814130 | lu-r 9
1814261 | lu-r 9
1814374 | lu-r 9
1814454 | lu-r 9
1814651 | lu-r 9
1814682 | lu-r 9
1816631 | lu-r 9
1816835 | lu-r 9
1816847 | lu-r 9
1816859 | lu-r 9
1816885 | lu-r 9
1816917 | lu-r 9
1816976 | lu-r 9
1816988 | lu-r 9
1817000 | lu-r 9
1827531 | lu-r 7

# IfcFlowTerminal: 160 (6)
In: 00_Begane Grond
Type - Description: RRVO; PredefinedType: GRILLE; Material: 57_Ral_9010
Pset_ManufacturerTypeInformation - Manufacturer: Solid Air
Pset_DistributionFlowElementCommon - Reference: 160
Group: lu-r 4
Name (NLRS_57_AIR_UN_Solid Air_RRVO:160:...)
1628365
1628551
1628578
1629268
1629545
1629810

# IfcFlowTerminal: 160, NLRS_57_AIR_UN_Solid Air_RTVO:160:1600941
In: 00_Begane Grond
Type - Description: RTVO; PredefinedType: GRILLE; Material: 57_Ral_9010
Pset_ManufacturerTypeInformation - Manufacturer: Solid Air
Pset_DistributionFlowElementCommon - Reference: 160
Group: lu-t 1

# IfcFlowTerminal: 160 (3)
In: 00_Begane Grond
Type - Description: Solid Air Diffuser swirl RTFO; PredefinedType: DIFFUSER; Material: 57_Ral_9010
Pset_ManufacturerTypeInformation - Manufacturer: Solid Air
Pset_DistributionFlowElementCommon - Reference: 160
Group: lu-t 6
Name (NLRS_57_AIR_UN_Solid Air_RTFO:160:...)
1624228
1625120
1625134

# IfcFlowTerminal: 250 (9)
In: 00_Begane Grond
Type - Description: Solid Air Diffuser swirl RTFO; PredefinedType: DIFFUSER; Material: 57_Ral_9010
Pset_ManufacturerTypeInformation - Manufacturer: Solid Air
Pset_DistributionFlowElementCommon - Reference: 250
Group: lu-t 3
Name (NLRS_57_AIR_UN_Solid Air_RTWK:250:...)
1735704
1740964
1741014
1742232
1742233
1742234
1742669
1742670
1742671

# IfcFlowTerminal: 415x115 (8)
In: 00_Begane Grond
Type - Description: WUCKVO; PredefinedType: DIFFUSER
Pset_ManufacturerTypeInformation - Manufacturer: Solid Air
Pset_DistributionFlowElementCommon - Reference: 415x115
Name (NLRS_57_AIR_UN_Solid Air_WUCK_Toevoer:415x115:...) | Group
1596278 | lu-t 1
1596378 | lu-t 1
1597339 | lu-t 1
1597374 | lu-t 1
1621326 | lu-t 6
1621383 | lu-t 6
1621406 | lu-t 6
1624060 | lu-t 6

# IfcFlowTerminal: 825x225 (20)
In: 00_Begane Grond
Type - Description: WUCKVO; PredefinedType: DIFFUSER
Pset_ManufacturerTypeInformation - Manufacturer: Solid Air
Pset_DistributionFlowElementCommon - Reference: 825x225
Name (NLRS_57_AIR_UN_Solid Air_WUCK_Toevoer:825x225:...) | Group
1411536 | lu-t 2
1411670 | lu-t 2
1411740 | lu-t 2
1411850 | lu-t 2
1438198 | lu-t 4
1438249 | lu-t 4
1438474 | lu-t 4
1438599 | lu-t 4
1438653 | lu-t 4
1439149 | lu-t 4
1439178 | lu-t 4
1564448 | lu-t 2
1572918 | lu-t 2
1572919 | lu-t 2
1572920 | lu-t 2
1572921 | lu-t 2
1572926 | lu-t 2
1616422 | lu-t 4
1616714 | lu-t 4
1617118 | lu-t 4

# IfcFlowTerminal: BSH03_Ajax_Euro 25 m 3/4" (12)
In: 00_Begane Grond
Type - PredefinedType: HOSEREEL; Material: Color RAL 3000, Color RGB 187-185-183
Pset_ManufacturerTypeInformation - Manufacturer: Ajax
Pset_DistributionFlowElementCommon - Reference: BSH03_Ajax_Euro 25 m 3/4"
Name (NLRS_65_PLF_Ajax_Euro 25 m DN20:BSH03_Ajax_Euro 25 m 3/4":...) | Group
1663435 | kwl 4
1669473 | kwl 4
1671899 | kwl 4
1672408 | kwl 4
1672948 | kwl 4
1673497 | kwl 4
1674734 | kwl 3
1675066 | kwl 4
1786085 | kwl 4
1786195 | kwl 4
1817585 | kwl 4
1817631 | kwl 4

# IfcFlowTerminal: DK-2-verzonken (4)
In: 00_Begane Grond
Type - PredefinedType: GRILLE; Classification: 57 (Uniformat); Material: NLRS_A_aluminium
Pset_ManufacturerTypeInformation - ArticleNumber: DK-2-verzonken; Manufacturer: Smitsair Luchttechniek
Pset_DistributionFlowElementCommon - Reference: DK-2-verzonken
Name (NLRS_57_AIR_FB_Dakkap DK-2 verzonken_SMA:DK-2-verzonken:...) | Group
1726865 | bla 6
1747273
1759183 | bla 4
1759285 | afb 6

# IfcFlowTerminal: DOS/AI (4)
In: 00_Begane Grond
Type - PredefinedType: GRILLE; Classification: 57 (Uniformat); Material: NLRS_A_aluminium
Pset_ManufacturerTypeInformation - ArticleNumber: DOS/AI; Manufacturer: Smitsair Luchttechniek
Pset_DistributionFlowElementCommon - Reference: DOS/AI
Name (NLRS_57_DUF_FB_Dakopstand DOS-AI_SH_SMA:DOS/AI:...)
1726866
1747274
1759184
1759286

# IfcFlowTerminal: Fixed Mounting Kit-19mm, M_Fire Hose Reel_F_MEPcontent_Chubb Fire & Security_Wall Mounted_Fixed Mounting Kit:Fixed Mounting Kit-19mm:1672410
In: 00_Begane Grond
Type - PredefinedType: HOSEREEL; Material: Color RAL 3000, Color RGB 187-185-183, Color RGB 212-140-110
Pset_DistributionFlowElementCommon - Reference: Fixed Mounting Kit-19mm

# IfcFlowTerminal: Fixed Mounting Kit-19mm (11)
In: 00_Begane Grond
Type - PredefinedType: HOSEREEL; Material: Color RGB 187-185-183, Color RAL 3000, Color RGB 212-140-110
Pset_DistributionFlowElementCommon - Reference: Fixed Mounting Kit-19mm
Name (M_Fire Hose Reel_F_MEPcontent_Chubb Fire & Security_Wall Mounted_Fixed Mounting Kit:Fixed Mounting Kit-19mm:...)
1663437
1669474
1671900
1672950
1673499
1674735
1675067
1786086
1786196
1817586
1817632

# IfcFlowTerminal: Rechthoekig Eindkap_Retour (7)
In: 00_Begane Grond
Pset_ManufacturerTypeInformation - Manufacturer: Generiek
Pset_DistributionFlowElementCommon - Reference: Rechthoekig Eindkap_Retour
Name (NLRS_57_AIR_UN_Gen_Rechthoekig Eindkap_Retour:Rechthoekig Eindkap_Retour:...) | Group
1581682 | lu-r 6
1601992 | lu-r 2
1602209 | lu-r 8
1602239 | lu-r 10
1602254 | lu-r 11
1606828 | lu-r 12
1612088 | lu-r 3

# IfcFlowTerminal: Rond Eindkap_Retour, NLRS_57_AIR_UN_Gen_Rond Eindkap_Retour:Rond Eindkap_Retour:1621218
In: 00_Begane Grond
Pset_ManufacturerTypeInformation - Manufacturer: Generiek
Pset_DistributionFlowElementCommon - Reference: Rond Eindkap_Retour
Group: lu-r 4

# IfcFlowTreatmentDevice: GD-200, NLRS_57_DUA_UN_Coulissengeluiddempers_SMA:GD-200:1764338
In: 00_Begane Grond
Type - PredefinedType: RECTANGULAR; Classification: 57 (Uniformat); Material: NLRS_A_staal Sendzimir verzinkt
Pset_ManufacturerTypeInformation - ArticleNumber: GD-200; Manufacturer: Smitsair Luchttechniek
Pset_DistributionFlowElementCommon - Reference: GD-200
Group: afb 6
