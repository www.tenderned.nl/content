Properties of the parts of a building model (IFC2X3), part 3 of 4

# IfcDistributionPort (4372)
Name | FlowDirection | Group
2 x InPort_1806481 | SOURCEANDSINK | cv-r 3
2 x OutPort_1806499 | SOURCEANDSINK | cv-r 3
2 x OutPort_1806503 | SOURCEANDSINK | cv-r 3
InPort_1806483 | SOURCEANDSINK | cv-r 3
2 x InPort_1806485 | SOURCEANDSINK | cv-r 3
OutPort_1806505 | SOURCEANDSINK | cv-r 3
2 x OutPort_1806509 | SOURCEANDSINK | cv-r 3
InPort_1806487 | SOURCEANDSINK | cv-r 3
2 x InPort_1806494 | SOURCEANDSINK | cv-r 3
InPort_1806499 | SOURCEANDSINK | cv-r 3
2 x OutPort_1806506 | SOURCEANDSINK | cv-r 3
2 x InPort_1806505 | SOURCEANDSINK | cv-r 3
2 x OutPort_1806531 | SOURCEANDSINK | cv-r 3
2 x InPort_1806515 | SOURCEANDSINK | cv-r 3
2 x OutPort_1807052 | SOURCEANDSINK | cv-r 3
InPort_1806525 | SOURCEANDSINK | cv-r 3
OutPort_1806526 | SOURCEANDSINK | cv-r 3
3 x InPort_1806533 | SOURCEANDSINK | cv-a 5
2 x OutPort_1806540 | SOURCEANDSINK | cv-a 5
OutPort_1806534 | SOURCEANDSINK | cv-a 5
3 x InPort_1806539 | SOURCEANDSINK | cv-a 5
2 x OutPort_1806546 | SOURCEANDSINK | cv-a 5
3 x InPort_1806545 | SOURCEANDSINK | cv-a 5
2 x OutPort_1806552 | SOURCEANDSINK | cv-a 5
3 x InPort_1806551 | SOURCEANDSINK | cv-a 5
2 x OutPort_1806558 | SOURCEANDSINK | cv-a 5
3 x InPort_1806557 | SOURCEANDSINK | cv-a 5
OutPort_1806563 | SOURCEANDSINK | cv-a 5
InPort_1806563 | SOURCEANDSINK | cv-a 5
OutPort_1807248 | SOURCEANDSINK | cv-a 5
2 x InPort_1806570 | SOURCEANDSINK | cv-a 5
2 x OutPort_1807250 | SOURCEANDSINK | cv-a 5
2 x OutPort_1807342 | SOURCEANDSINK | cv-a 5
InPort_1806816 | SOURCEANDSINK | cv-r 3
InPort_1806842 | SOURCEANDSINK | cv-r 3
2 x InPort_1806899 | SOURCEANDSINK | cv-a 5
2 x OutPort_1806905 | SOURCEANDSINK | cv-a 5
InPort_1806903 | SOURCEANDSINK | cv-a 5
2 x InPort_1807050 | SOURCEANDSINK | cv-r 3
2 x OutPort_1807206 | SOURCEANDSINK | cv-r 3
2 x InPort_1807198 | SOURCEANDSINK | cv-r 3
2 x OutPort_1807425 | SOURCEANDSINK | cv-r 3
InPort_1807248 | SOURCEANDSINK | cv-a 5
2 x InPort_1807334 | SOURCEANDSINK | cv-a 5
2 x OutPort_1807391 | SOURCEANDSINK | cv-a 5
2 x InPort_1807385 | SOURCEANDSINK | cv-a 5
OutPort_1807453 | SOURCEANDSINK | cv-a 5
2 x InPort_1807415 | SOURCEANDSINK | cv-r 3
2 x OutPort_1807487 | SOURCEANDSINK | cv-r 3
InPort_1807453 | SOURCEANDSINK | cv-a 5
OutPort_1807527 | SOURCEANDSINK | cv-a 5
2 x InPort_1807479 | SOURCEANDSINK | cv-r 3
2 x OutPort_1807512 | SOURCEANDSINK | cv-r 3
InPort_1807504 | SOURCEANDSINK | cv-r 3
InPort_1807527 | SOURCEANDSINK | cv-a 5
2 x OutPort_1807541 | SOURCEANDSINK | cv-a 5
InPort_1807535 | SOURCEANDSINK | cv-a 5
InPort_1813765 | SINK | lu-r 9
OutPort_1813794 | SOURCE | lu-r 9
2 x InPort_1813778 | SINK | lu-r 9
OutPort_1813765 | SOURCE | lu-r 9
InPort_1813779 | SINK | lu-r 9
OutPort_1813778 | SOURCE | lu-r 9
OutPort_1814558 | SOURCE | lu-r 9
InPort_1813786 | SINK | lu-r 9
OutPort_1813803 | SOURCE | lu-r 9
InPort_1813794 | SINK | lu-r 9
OutPort_1813786 | SOURCE | lu-r 9
InPort_1813797 | SINK | lu-r 9
OutPort_1813910 | SOURCE | lu-r 9
2 x InPort_1814053 | SINK | lu-r 9
OutPort_1813797 | SOURCE | lu-r 9
InPort_1813803 | SINK | lu-r 9
OutPort_1814040 | SOURCE | lu-r 9
InPort_1813910 | SINK | lu-r 9
OutPort_1813897 | SOURCE | lu-r 9
InPort_1813897 | SINK | lu-r 9
OutPort_1814454 | SOURCE | lu-r 9
OutPort_1814002 | SOURCE | lu-r 9
InPort_1814002 | SINK | lu-r 9
OutPort_1814374 | SOURCE | lu-r 9
2 x InPort_1814046 | SINK | lu-r 9
OutPort_1814011 | SOURCE | lu-r 9
InPort_1814011 | SINK | lu-r 9
OutPort_1814261 | SOURCE | lu-r 9
2 x InPort_1814039 | SINK | lu-r 9
OutPort_1814022 | SOURCE | lu-r 9
InPort_1814022 | SINK | lu-r 9
OutPort_1814130 | SOURCE | lu-r 9
InPort_1814040 | SINK | lu-r 9
OutPort_1814039 | SOURCE | lu-r 9
OutPort_1814047 | SOURCE | lu-r 9
OutPort_1814054 | SOURCE | lu-r 9
InPort_1814047 | SINK | lu-r 9
OutPort_1814046 | SOURCE | lu-r 9
InPort_1814054 | SINK | lu-r 9
OutPort_1814053 | SOURCE | lu-r 9
InPort_1814548 | SINK | lu-r 9
OutPort_1814586 | SOURCE | lu-r 9
2 x InPort_1814610 | SINK | lu-r 9
OutPort_1814548 | SOURCE | lu-r 9
2 x InPort_1814557 | SINK | lu-r 9
OutPort_1814829 | SOURCE | lu-r 9
InPort_1814558 | SINK | lu-r 9
OutPort_1814557 | SOURCE | lu-r 9
OutPort_1814611 | SOURCE | lu-r 9
InPort_1814586 | SINK | lu-r 9
OutPort_1814580 | SOURCE | lu-r 9
InPort_1814580 | SINK | lu-r 9
OutPort_1814682 | SOURCE | lu-r 9
InPort_1814602 | SINK | lu-r 9
OutPort_1814651 | SOURCE | lu-r 9
OutPort_1814602 | SOURCE | lu-r 9
InPort_1814611 | SINK | lu-r 9
OutPort_1814610 | SOURCE | lu-r 9
2 x InPort_1814828 | SINK | lu-r 9
OutPort_1814820 | SOURCE | lu-r 9
InPort_1814820 | SINK | lu-r 9
OutPort_1816542 | SOURCE | lu-r 9
InPort_1814829 | SINK | lu-r 9
OutPort_1814828 | SOURCE | lu-r 9
OutPort_1814850 | SOURCE | lu-r 9
InPort_1814843 | SINK | lu-r 9
OutPort_1817036 | SOURCE | lu-r 9
2 x InPort_1814849 | SINK | lu-r 9
OutPort_1814843 | SOURCE | lu-r 9
OutPort_1816504 | SOURCE | lu-r 9
InPort_1814850 | SINK | lu-r 9
OutPort_1814849 | SOURCE | lu-r 9
InPort_1816132 | SINK | lu-r 9
OutPort_1817032 | SOURCE | lu-r 9
2 x InPort_1816305 | SINK | lu-r 9
OutPort_1816132 | SOURCE | lu-r 9
2 x InPort_1816369 | SINK | lu-r 9
OutPort_1816143 | SOURCE | lu-r 9
InPort_1816143 | SINK | lu-r 9
OutPort_1817044 | SOURCE | lu-r 9
2 x InPort_1817061 | SINK | lu-r 9
OutPort_1816156 | SOURCE | lu-r 9
InPort_1816156 | SINK | lu-r 9
OutPort_1817057 | SOURCE | lu-r 9
InPort_1816219 | SINK | lu-r 9
OutPort_1817016 | SOURCE | lu-r 9
2 x InPort_1817020 | SINK | lu-r 9
OutPort_1816219 | SOURCE | lu-r 9
InPort_1816230 | SINK | lu-r 9
OutPort_1817040 | SOURCE | lu-r 9
2 x InPort_1816323 | SINK | lu-r 9
OutPort_1816230 | SOURCE | lu-r 9
2 x InPort_1817052 | SINK | lu-r 9
OutPort_1816252 | SOURCE | lu-r 9
InPort_1816252 | SINK | lu-r 9
OutPort_1817048 | SOURCE | lu-r 9
InPort_1817072 | SINK | lu-r 9
OutPort_1816263 | SOURCE | lu-r 9
InPort_1816263 | SINK | lu-r 9
OutPort_1817068 | SOURCE | lu-r 9
OutPort_1816324 | SOURCE | lu-r 9
InPort_1816315 | SINK | lu-r 9
OutPort_1816305 | SOURCE | lu-r 9
OutPort_1816315 | SOURCE | lu-r 9
OutPort_1816370 | SOURCE | lu-r 9
InPort_1816506 | SINK | lu-r 9
OutPort_1816323 | SOURCE | lu-r 9
InPort_1816324 | SINK | lu-r 9
OutPort_1816506 | SOURCE | lu-r 9
OutPort_1816478 | SOURCE | lu-r 9
InPort_1816370 | SINK | lu-r 9
OutPort_1816369 | SOURCE | lu-r 9
InPort_1816398 | SINK | lu-r 9
OutPort_1817072 | SOURCE | lu-r 9
OutPort_1816398 | SOURCE | lu-r 9
InPort_1816478 | SINK | lu-r 9
OutPort_1817053 | SOURCE | lu-r 9
InPort_1816504 | SINK | lu-r 9
OutPort_1817021 | SOURCE | lu-r 9
InPort_1816534 | SINK | lu-r 9
OutPort_1816631 | SOURCE | lu-r 9
InPort_1816542 | SINK | lu-r 9
OutPort_1816534 | SOURCE | lu-r 9
InPort_1816833 | SINK | lu-r 9
OutPort_1816835 | SOURCE | lu-r 9
InPort_1817016 | SINK | lu-r 9
OutPort_1816833 | SOURCE | lu-r 9
InPort_1817040 | SINK | lu-r 9
OutPort_1816845 | SOURCE | lu-r 9
InPort_1816845 | SINK | lu-r 9
OutPort_1816847 | SOURCE | lu-r 9
InPort_1816857 | SINK | lu-r 9
OutPort_1816859 | SOURCE | lu-r 9
InPort_1817048 | SINK | lu-r 9
OutPort_1816857 | SOURCE | lu-r 9
InPort_1816883 | SINK | lu-r 9
OutPort_1816885 | SOURCE | lu-r 9
InPort_1817068 | SINK | lu-r 9
OutPort_1816883 | SOURCE | lu-r 9
InPort_1816915 | SINK | lu-r 9
OutPort_1816917 | SOURCE | lu-r 9
InPort_1817036 | SINK | lu-r 9
OutPort_1816915 | SOURCE | lu-r 9
InPort_1817032 | SINK | lu-r 9
OutPort_1816974 | SOURCE | lu-r 9
InPort_1816974 | SINK | lu-r 9
OutPort_1816976 | SOURCE | lu-r 9
InPort_1816986 | SINK | lu-r 9
OutPort_1816988 | SOURCE | lu-r 9
InPort_1817044 | SINK | lu-r 9
OutPort_1816986 | SOURCE | lu-r 9
InPort_1817057 | SINK | lu-r 9
OutPort_1816998 | SOURCE | lu-r 9
InPort_1816998 | SINK | lu-r 9
OutPort_1817000 | SOURCE | lu-r 9
InPort_1817021 | SINK | lu-r 9
OutPort_1817020 | SOURCE | lu-r 9
InPort_1817053 | SINK | lu-r 9
OutPort_1817052 | SOURCE | lu-r 9
OutPort_1817062 | SOURCE | lu-r 9
InPort_1817062 | SINK | lu-r 9
OutPort_1817061 | SOURCE | lu-r 9
InPort_1817203 | SOURCEANDSINK | gas 2
2 x OutPort_1817207 | SOURCEANDSINK | gas 2
InPort_1817205 | SOURCEANDSINK | gas 2
2 x InPort_1817473 | SOURCEANDSINK | kwl 4
2 x OutPort_1823537 | SOURCEANDSINK | kwl 4
OutPort_1817475 | SOURCEANDSINK | kwl 4
InPort_1817481 | SINK | kwl 4
OutPort_1817475 | SOURCE | kwl 4
InPort_1817475 | SOURCEANDSINK | kwl 4
InPort_1817585 | SINK | kwl 4
OutPort_1821029 | SOURCE | kwl 4
InPort_1817631 | SINK | kwl 4
OutPort_1821034 | SOURCE | kwl 4
InPort_1818094 | SOURCEANDSINK | vwa 8
2 x OutPort_1818229 | SOURCEANDSINK | vwa 8
InPort_1818096 | SOURCEANDSINK | vwa 8
InPort_1818376 | SOURCEANDSINK | vwa 9
2 x OutPort_1818380 | SOURCEANDSINK | vwa 9
InPort_1818378 | SOURCEANDSINK | vwa 9
InPort_1818390 | SOURCEANDSINK | vwa 10
2 x OutPort_1818394 | SOURCEANDSINK | vwa 10
InPort_1818392 | SOURCEANDSINK | vwa 10
InPort_1818406 | SOURCEANDSINK | vwa 11
2 x OutPort_1818410 | SOURCEANDSINK | vwa 11
InPort_1818408 | SOURCEANDSINK | vwa 11
InPort_1818558 | SOURCEANDSINK | vwa 12
2 x OutPort_1818574 | SOURCEANDSINK | vwa 12
2 x InPort_1818568 | SOURCEANDSINK | vwa 12
2 x OutPort_1818609 | SOURCEANDSINK | vwa 12
InPort_1818606 | SOURCEANDSINK | vwa 12
InPort_1818690 | SOURCEANDSINK | vwa 13
2 x OutPort_1818694 | SOURCEANDSINK | vwa 13
2 x InPort_1818692 | SOURCEANDSINK | vwa 13
2 x OutPort_1818698 | SOURCEANDSINK | vwa 13
InPort_1818696 | SOURCEANDSINK | vwa 13
2 x InPort_1820130 | SOURCEANDSINK | kwl 4
2 x OutPort_1820251 | SOURCEANDSINK | kwl 4
2 x InPort_1820168 | SOURCEANDSINK | kwl 4
2 x OutPort_1820271 | SOURCEANDSINK | kwl 4
2 x OutPort_1820172 | SOURCEANDSINK | kwl 4
2 x InPort_1820170 | SOURCEANDSINK | kwl 4
2 x OutPort_1820284 | SOURCEANDSINK | kwl 4
2 x InPort_1820174 | SOURCEANDSINK | kwl 4
2 x OutPort_1820286 | SOURCEANDSINK | kwl 4
2 x OutPort_1820280 | SOURCEANDSINK | kwl 4
2 x InPort_1820176 | SOURCEANDSINK | kwl 4
2 x OutPort_1826641 | SOURCEANDSINK | kwl 4
2 x InPort_1820178 | SOURCEANDSINK | kwl 4
3 x OutPort_1820297 | SOURCEANDSINK | kwl 4
2 x OutPort_1820182 | SOURCEANDSINK | kwl 4
2 x InPort_1820180 | SOURCEANDSINK | kwl 4
InPort_1820191 | SOURCEANDSINK | kwl 4
2 x OutPort_1820199 | SOURCEANDSINK | kwl 4
2 x InPort_1820193 | SOURCEANDSINK | kwl 4
2 x OutPort_1820203 | SOURCEANDSINK | kwl 4
2 x InPort_1820195 | SOURCEANDSINK | kwl 4
2 x OutPort_1820205 | SOURCEANDSINK | kwl 4
2 x InPort_1820197 | SOURCEANDSINK | kwl 4
InPort_1820209 | SINK | kwl 4
OutPort_1820271 | SOURCE | kwl 4
InPort_1820222 | SOURCEANDSINK | kwl 4
InPort_1820224 | SOURCEANDSINK | kwl 4
InPort_1820226 | SINK | kwl 4
OutPort_1820233 | SOURCE | kwl 4
InPort_1820228 | SINK | kwl 4
OutPort_1820286 | SOURCE | kwl 4
InPort_1820233 | SINK | kwl 4
OutPort_1820228 | SOURCE | kwl 4
2 x InPort_1820239 | SOURCEANDSINK | kwl 4
2 x OutPort_1820253 | SOURCEANDSINK | kwl 4
2 x InPort_1820241 | SOURCEANDSINK | kwl 4
2 x OutPort_1820257 | SOURCEANDSINK | kwl 4
2 x InPort_1820243 | SOURCEANDSINK | kwl 4
2 x OutPort_1820261 | SOURCEANDSINK | kwl 4
2 x InPort_1820245 | SOURCEANDSINK | kwl 4
2 x OutPort_1820265 | SOURCEANDSINK | kwl 4
2 x InPort_1820247 | SOURCEANDSINK | kwl 4
2 x OutPort_1820269 | SOURCEANDSINK | kwl 4
2 x InPort_1820249 | SOURCEANDSINK | kwl 4
InPort_1820280 | SOURCEANDSINK | kwl 4
2 x InPort_1820533 | SOURCEANDSINK | kwl 4
2 x OutPort_1823535 | SOURCEANDSINK | kwl 4
2 x InPort_1820989 | SOURCEANDSINK | kwl 4
2 x OutPort_1821059 | SOURCEANDSINK | kwl 4
2 x OutPort_1821057 | SOURCEANDSINK | kwl 4
2 x InPort_1820991 | SOURCEANDSINK | kwl 4
3 x OutPort_1821068 | SOURCEANDSINK | kwl 4
2 x InPort_1820993 | SOURCEANDSINK | kwl 4
3 x OutPort_1821070 | SOURCEANDSINK | kwl 4
3 x OutPort_1821072 | SOURCEANDSINK | kwl 4
2 x InPort_1820995 | SOURCEANDSINK | kwl 4
3 x OutPort_1821074 | SOURCEANDSINK | kwl 4
2 x InPort_1820997 | SOURCEANDSINK | kwl 4
InPort_1820999 | SOURCEANDSINK | kwl 4
2 x InPort_1821001 | SOURCEANDSINK | kwl 4
2 x OutPort_1821013 | SOURCEANDSINK | kwl 4
2 x InPort_1821003 | SOURCEANDSINK | kwl 4
2 x OutPort_1821015 | SOURCEANDSINK | kwl 4
2 x InPort_1821005 | SOURCEANDSINK | kwl 4
2 x OutPort_1821019 | SOURCEANDSINK | kwl 4
2 x InPort_1821007 | SOURCEANDSINK | kwl 4
2 x OutPort_1821023 | SOURCEANDSINK | kwl 4
2 x InPort_1821009 | SOURCEANDSINK | kwl 4
2 x OutPort_1821027 | SOURCEANDSINK | kwl 4
2 x InPort_1821011 | SOURCEANDSINK | kwl 4
OutPort_1821053 | SOURCEANDSINK | kwl 4
InPort_1821029 | SINK | kwl 4
OutPort_1821053 | SOURCE | kwl 4
InPort_1821034 | SINK | kwl 4
OutPort_1821059 | SOURCE | kwl 4
InPort_1821039 | SOURCEANDSINK | kwl 4
2 x OutPort_1821043 | SOURCEANDSINK | kwl 4
2 x InPort_1821041 | SOURCEANDSINK | kwl 4
InPort_1821047 | SOURCEANDSINK | kwl 4
InPort_1821049 | SOURCEANDSINK | kwl 4
InPort_1821051 | SOURCEANDSINK | kwl 4
InPort_1821053 | SOURCEANDSINK | kwl 4

# IfcFlowController: DN50 (4)
In: 00_Begane Grond
Pset_ManufacturerTypeInformation - Manufacturer: Generiek
Pset_DistributionFlowElementCommon - Reference: DN50
Name (NLRS_50_PIA_HOS_voorlasflens:DN50:...) | Group
1644076 | cv-r 1
1644079 | cv-r 1
1644088 | cv-a 4
1644091 | cv-a 4

# IfcFlowController: Trox_EN-1000x500, NLRS_57_DUA_UN_Trox_EN:Trox_EN-1000x500:1708804
In: 00_Begane Grond
Type - PredefinedType: CONTROLDAMPER; Material: Solid fill
Pset_ManufacturerTypeInformation - Manufacturer: Trox
Pset_DistributionFlowElementCommon - Reference: Trox_EN-1000x500
Group: lu-t 2

# IfcFlowController: Type 22 (20)
In: 00_Begane Grond
Pset_ManufacturerTypeInformation - Manufacturer: Generiek
Pset_DistributionFlowElementCommon - Reference: Type 22
Name (NLRS_56_PIA_UN_Generiek_Radiator:Type 22:...)
1798318
1798388
1798441
1798449
1798457
1798465
1798477
1798485
1798493
1798503
1798511
1798519
1798527
1798537
1798545
1798771
1827414
1827453
1827464
1827474

# IfcFlowController: verzinkt_staal (48)
In: 00_Begane Grond
Type - Description: Regelklep handbediend; PredefinedType: CONTROLDAMPER; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: n.t.b.
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal
Name (NLRS_57_DUA_UN_regelklep rond_Luka:verzinkt_staal:...) | Group
1587335 | lu-r 1
1587715 | lu-r 1
1587759 | lu-r 1
1588260 | lu-r 1
1588267 | lu-r 1
1588353 | lu-r 1
1588424 | lu-r 1
1588454 | lu-r 1
1588480 | lu-r 1
1588563 | lu-r 1
1588582 | lu-r 1
1589430 | lu-r 1
1589537 | lu-r 1
1589959 | lu-r 1
1590342 | lu-r 1
1590369 | lu-r 1
1590390 | lu-r 1
1590411 | lu-r 1
1591666 | lu-r 1
1591749 | lu-r 1
1593252 | lu-r 1
1593373 | lu-r 1
1605220 | lu-t 3
1605250 | lu-t 3
1606186 | lu-t 3
1606189 | lu-t 3
1629013 | lu-r 4
1629029 | lu-r 4
1629149 | lu-r 4
1629336 | lu-r 4
1630130 | lu-r 4
1630241 | lu-r 4
1638212 | lu-t 6
1638280 | lu-t 6
1638360 | lu-r 4
1638442 | lu-t 6
1638573 | lu-t 6
1639254 | lu-r 4
1741965 | lu-t 3
1743585 | lu-t 3
1743727 | lu-t 3
1743999 | lu-t 3
1796538 | lu-r 7
1796624 | lu-r 7
1796712 | lu-r 7
1796748 | lu-r 7
1796842 | lu-r 7
1797081 | lu-r 7

# IfcFlowFitting: 30º verzinkt_staal (6)
In: 00_Begane Grond
Type - Description: Rechthoek op rond - verloopstuk; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: 30º verzinkt_staal
Name (NLRS_57_DUF_UN_rechth verloop rhor_Luka:30º verzinkt_staal:...) | Group
1592363 | lu-r 1
1592364 | lu-r 1
1592454 | lu-r 1
1592822 | lu-r 1
1688230 | lu-t 2
1688595 | lu-t 2

# IfcFlowFitting: 30º verzinkt_staal (7)
In: 00_Begane Grond
Type - Description: Rechthoekig - verloopstuk; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: 30º verzinkt_staal
Name (NLRS_57_DUF_UN_rechth verloop_Luka:30º verzinkt_staal:...) | Group
1617731 | lu-t 4
1617733 | lu-t 4
1617742 | lu-t 4
1617744 | lu-t 4
1617745 | lu-t 4
1617746 | lu-t 4
1753655 | lu-t 2

# IfcFlowFitting: 30º verzinkt_staal 2, NLRS_57_DUF_UN_rechth verloop rhor_Luka:30º verzinkt_staal 2:1724347
In: 00_Begane Grond
Type - Description: Rechthoek op rond - verloopstuk; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: 30º verzinkt_staal 2
Group: afb 5

# IfcFlowFitting: 30º verzinkt_staal 2, NLRS_57_DUF_UN_rechth verloop_Luka:30º verzinkt_staal 2:1748959
In: 00_Begane Grond
Type - Description: Rechthoekig - verloopstuk; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: 30º verzinkt_staal 2
Group: afb 4

# IfcFlowFitting: 60º verzinkt_staal (15)
In: 00_Begane Grond
Type - Description: Rechthoekig - verloopstuk; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: 60º verzinkt_staal
Name (NLRS_57_DUF_UN_rechth verloop_Luka:60º verzinkt_staal:...) | Group
1614631 | lu-t 4
1614704 | lu-t 4
1614819 | lu-t 4
1688244 | lu-t 2
1693832 | lu-t 2
1693833 | lu-t 2
1727033 | bla 6
1752750 | lu-t 2
1754551 | lu-t 2
1758721 | afb 6
1759879 | bla 4
1760856 | afb 6
1764515 | afb 6
1764516 | afb 6
1765572 | bla 4

# IfcFlowFitting: EuroAir - DV-Down, EuroAir - DV-Down:EuroAir - DV-Down:1729285
In: 00_Begane Grond
Pset_ManufacturerTypeInformation - Manufacturer: EuroAir
Pset_DistributionFlowElementCommon - Reference: EuroAir - DV-Down

# IfcFlowFitting: EuroAir - DV-Straight (2)
In: 00_Begane Grond
Type - Material: Textile
Pset_ManufacturerTypeInformation - Manufacturer: EuroAir
Pset_DistributionFlowElementCommon - Reference: EuroAir - DV-Straight
Name (EuroAir - DV-Straight:EuroAir - DV-Straight:...)
1729577
1730336

# IfcFlowFitting: NLRS_50_PIF_HOS_lassok_GEN (14)
In: 00_Begane Grond
Pset_DistributionFlowElementCommon - Reference: NLRS_50_PIF_HOS_lassok_GEN
Name (NLRS_50_PIF_HOS_lassok_GEN:NLRS_50_PIF_HOS_lassok_GEN:...) | Group
1644074 | cv-r 1
1644082 | cv-r 1
1644086 | cv-a 4
1644094 | cv-a 4
1644098 | cv-r 1
1644104 | cv-a 4
1644116 | cv-r 1
1644118 | cv-r 1
1644120 | cv-a 4
1644122 | cv-a 4
1644124 | cv-a 4
1644126 | cv-r 1
1644786 | cv-a 4
1644835 | cv-a 4

# IfcFlowFitting: NLRS_57_DUF_Kanaalsplitsing horizontaal_1 afgaande_Gen, NLRS_57_DUF_Kanaalsplitsing horizontaal_1 afgaande_Gen:NLRS_57_DUF_Kanaalsplitsing horizontaal_1 afgaande_Gen:1612261
In: 00_Begane Grond
Pset_DistributionFlowElementCommon - Reference: NLRS_57_DUF_Kanaalsplitsing horizontaal_1 afgaande_Gen
Group: lu-r 3

# IfcFlowFitting: NLRS_57_DUF_UN_Horizontale plaat 2 aftakkingen (3)
In: 00_Begane Grond
Pset_DistributionFlowElementCommon - Reference: NLRS_57_DUF_UN_Horizontale plaat 2 aftakkingen
Name | Group
NLRS_57_DUF_Kanaalsplitsing horizontaal_2 afgaande_Gen:NLRS_57_DUF_UN_Horizontale plaat 2 aftakkingen:1580310 | lu-t 2
NLRS_57_DUF_Kanaalsplitsing horizontaal_3 afgaande_Gen:NLRS_57_DUF_UN_Horizontale plaat 2 aftakkingen:1614195 | lu-t 4
NLRS_57_DUF_Kanaalsplitsing horizontaal_2 afgaande_Gen:NLRS_57_DUF_UN_Horizontale plaat 2 aftakkingen:1615654 | lu-t 4

# IfcFlowFitting: Standard (43)
In: 00_Begane Grond
Pset_DistributionFlowElementCommon - Reference: Standard
Name | Group
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1643508 | cv-a 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1643642 | cv-r 1
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1643847 | cv-a 1
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1643849 | cv-a 1
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1643851 | cv-r 1
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1643853 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1646011 | cv-r 1
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1646037 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1648269 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1648359 | cv-a 4
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1648603 | cv-a 4
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1648626 | cv-r 1
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1648642 | cv-a 4
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1648658 | cv-a 4
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1648672 | cv-r 1
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1648674 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1648741 | cv-a 4
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1648752 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1649150 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1652688 | cv-a 4
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1652712 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1653161 | cv-a 4
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1653527 | cv-r 1
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1654141 | cv-a 4
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1654143 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1654170 | cv-a 4
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1654267 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1655017 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1655029 | cv-a 4
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1660675 | cv-a 4
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1660699 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1660718 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1660750 | cv-a 4
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1676336 | cv-a 4
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1676338 | cv-r 1
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1676340 | cv-r 1
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1676342 | cv-a 4
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1767115 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1767180 | cv-a 4
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1767672 | cv-r 1
NLRS_50_PIF_HOS_verloopstuk_vlampijp ND:Standard:1767674 | cv-a 4
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1768846 | cv-r 1
NLRS_50_PIF_HOS_tstuk_vlampijp:Standard:1768880 | cv-a 4

# IfcFlowFitting: Standard (130)
Type - Classification: 5- (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Standard
Name (NLRS_50_PIF_HOS_bochtstuk_vlampijp:Standard:...) | In | Group
1344872 | -1_Kruipruimte | kwl 1
1344911 | -1_Kruipruimte | kwl 2
1643427 | 00_Begane Grond | cv-a 1
1643465 | 00_Begane Grond | cv-r 1
1645043 | 00_Begane Grond | cv-r 1
1645078 | 00_Begane Grond | cv-a 1
1645105 | 00_Begane Grond | cv-a 1
1645206 | 00_Begane Grond | cv-r 1
1645214 | 00_Begane Grond | cv-r 1
1645241 | 00_Begane Grond | cv-a 1
1645251 | 00_Begane Grond | cv-a 1
1645691 | 00_Begane Grond | cv-r 1
1646005 | 00_Begane Grond | cv-a 1
1646112 | 00_Begane Grond | cv-r 1
1646981 | 00_Begane Grond | cv-a 4
1647000 | 00_Begane Grond | cv-r 1
1647019 | 00_Begane Grond | cv-a 4
1647183 | 00_Begane Grond | cv-r 1
1647228 | 00_Begane Grond | cv-a 4
1647252 | 00_Begane Grond | cv-r 1
1647279 | 00_Begane Grond | cv-a 4
1648296 | 00_Begane Grond | cv-r 1
1648318 | 00_Begane Grond | cv-r 1
1648477 | 00_Begane Grond | cv-a 4
1648745 | 00_Begane Grond | cv-a 4
1648756 | 00_Begane Grond | cv-r 1
1648781 | 00_Begane Grond | cv-r 1
1648789 | 00_Begane Grond | cv-r 1
1648840 | 00_Begane Grond | cv-a 4
1649003 | 00_Begane Grond | cv-a 4
1649016 | 00_Begane Grond | cv-a 4
1649129 | 00_Begane Grond | cv-a 4
1649177 | 00_Begane Grond | cv-r 1
1649185 | 00_Begane Grond | cv-r 1
1649233 | 00_Begane Grond | cv-a 4
1649241 | 00_Begane Grond | cv-a 4
1649637 | 00_Begane Grond | cv-r 1
1649701 | 00_Begane Grond | cv-r 1
1652563 | 00_Begane Grond | cv-a 4
1652565 | 00_Begane Grond | cv-a 4
1652575 | 00_Begane Grond | cv-r 1
1652579 | 00_Begane Grond | cv-r 1
1652583 | 00_Begane Grond | cv-a 4
1652587 | 00_Begane Grond | cv-a 4
1652851 | 00_Begane Grond | cv-r 1
1652885 | 00_Begane Grond | cv-r 1
1652915 | 00_Begane Grond | cv-a 4
1653060 | 00_Begane Grond | cv-a 4
1653068 | 00_Begane Grond | cv-a 4
1653121 | 00_Begane Grond | cv-r 1
1653129 | 00_Begane Grond | cv-r 1
1653708 | 00_Begane Grond | cv-r 1
1653760 | 00_Begane Grond | cv-r 1
1653802 | 00_Begane Grond | cv-r 1
1653831 | 00_Begane Grond | cv-r 1
1653870 | 00_Begane Grond | cv-a 4
1653893 | 00_Begane Grond | cv-a 4
1653901 | 00_Begane Grond | cv-a 4
1654078 | 00_Begane Grond | cv-a 4
1654101 | 00_Begane Grond | cv-r 1
1654475 | 00_Begane Grond | cv-r 1
1654517 | 00_Begane Grond | cv-a 4
1654648 | 00_Begane Grond | cv-r 1
1654691 | 00_Begane Grond | cv-a 4
1655022 | 00_Begane Grond | cv-r 1
1655033 | 00_Begane Grond | cv-a 4
1655073 | 00_Begane Grond | cv-r 1
1655112 | 00_Begane Grond | cv-a 4
1655174 | 00_Begane Grond | cv-a 4
1655196 | 00_Begane Grond | cv-r 1
1655383 | 00_Begane Grond | cv-r 1
1655432 | 00_Begane Grond | cv-r 1
1655480 | 00_Begane Grond | cv-r 1
1655599 | 00_Begane Grond | cv-r 1
1655692 | 00_Begane Grond | cv-a 4
1655716 | 00_Begane Grond | cv-r 1
1655801 | 00_Begane Grond | cv-a 4
1655899 | 00_Begane Grond | cv-a 4
1655923 | 00_Begane Grond | cv-a 4
1655968 | 00_Begane Grond | cv-a 4
1656119 | 00_Begane Grond | cv-a 4
1656143 | 00_Begane Grond | cv-r 1
1656289 | 00_Begane Grond | cv-r 1
1656312 | 00_Begane Grond | cv-a 4
1660039 | 00_Begane Grond | cv-a 4
1660070 | 00_Begane Grond | cv-r 1
1660117 | 00_Begane Grond | cv-r 1
1660149 | 00_Begane Grond | cv-a 4
1660203 | 00_Begane Grond | cv-r 1
1660228 | 00_Begane Grond | cv-a 4
1660252 | 00_Begane Grond | cv-r 1
1660282 | 00_Begane Grond | cv-a 4
1660340 | 00_Begane Grond | cv-a 4
1660350 | 00_Begane Grond | cv-a 4
1660384 | 00_Begane Grond | cv-a 4
1660445 | 00_Begane Grond | cv-r 1
1660455 | 00_Begane Grond | cv-r 1
1660471 | 00_Begane Grond | cv-r 1
1660793 | 00_Begane Grond | cv-a 4
1660805 | 00_Begane Grond | cv-a 4
1660850 | 00_Begane Grond | cv-r 1
1666963 | 00_Begane Grond | cv-a 4
1766688 | 00_Begane Grond | cv-a 4
1766769 | 00_Begane Grond | cv-r 1
1766898 | 00_Begane Grond | cv-a 4
1766929 | 00_Begane Grond | cv-r 1
1767127 | 00_Begane Grond | cv-r 1
1767141 | 00_Begane Grond | cv-r 1
1767339 | 00_Begane Grond | cv-a 4
1767647 | 00_Begane Grond | cv-a 4
1767652 | 00_Begane Grond | cv-a 4
1767716 | 00_Begane Grond | cv-a 4
1767820 | 00_Begane Grond | cv-r 1
1767830 | 00_Begane Grond | cv-r 1
1768077 | 00_Begane Grond | cv-r 1
1768097 | 00_Begane Grond | cv-r 1
1768202 | 00_Begane Grond | cv-a 4
1768310 | 00_Begane Grond | cv-a 4
1768314 | 00_Begane Grond | cv-a 4
1768333 | 00_Begane Grond | cv-a 4
1768389 | 00_Begane Grond | cv-r 1
1768453 | 00_Begane Grond | cv-a 4
1768494 | 00_Begane Grond | cv-a 4
1768723 | 00_Begane Grond | cv-r 1
1768980 | 00_Begane Grond | cv-a 4
1769009 | 00_Begane Grond | cv-r 1
1769088 | 00_Begane Grond | cv-a 4
1769118 | 00_Begane Grond | cv-r 1
1769245 | 00_Begane Grond | cv-r 1
1769304 | 00_Begane Grond | cv-a 4

# IfcFlowFitting: Standard 2 (15)
In: 00_Begane Grond
Type - Classification: 5- (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Standard 2
Name (NLRS_50_PIF_HOS_bochtstuk_vlampijp:Standard 2:...) | Group
1644106 | cv-a 4
1644173 | cv-r 1
1644180 | cv-a 4
1644190 | cv-a 4
1644198 | cv-a 4
1644204 | cv-a 4
1644206 | cv-r 1
1644208 | cv-a 4
1644210 | cv-r 1
1644789 | cv-a 4
1644837 | cv-a 4
1645712 | cv-a 1
1645995 | cv-r 1
1646001 | cv-a 1
1646018 | cv-r 1

# IfcFlowFitting: Var. DN (140)
In: 00_Begane Grond
Type - Description: Bend Mapress Copper; PredefinedType: BEND; Material: Geberit_Plastic , Paint Finish, White, NLRS_h5_koper_DHP
Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var. DN
Name (NLRS_50_PIF_Mapress-Cu Bend_Geberit:Var. DN:...) | ArticleNumber | Group
1661569 | 60105 | kwl 4
1661590 | 60105 | kwl 4
1661642 | 60105 | kwl 4
1661652 | 60105 | kwl 4
1661689 | 60105 | kwl 4
1661699 | 60105 | kwl 4
1661731 | 60105 | kwl 4
1661755 | 60105 | kwl 4
1661951 | 60105 | kwl 4
1661988 | 60105 | kwl 4
1662080 | 60105 | kwl 4
1662093 | 60105 | kwl 4
1662563 | 60605 | kwl 4
1662580 | 60605 | kwl 4
1663221 | 60605 | kwl 4
1663225 | 60105 | kwl 4
1663423 | 60105 | kwl 4
1664407 | 60104 | kwl 4
1664409 | 60104 | kwl 4
1664914 | 60102 | kwl 4
1665076 | 60102 | kwl 4
1665112 | 60102 | kwl 4
1665134 | 60102 | kwl 4
1665154 | 60102 | kwl 4
1665168 | 60102 | kwl 4
1665174 | 60102 | kwl 4
1665208 | 60102 | kwl 8
1665214 | 60102 | kwl 8
1665299 | 60102 | kwl 4
1665345 | 60102 | kwl 4
1665354 | 60102 | kwl 4
1665368 | 60102 | kwl 4
1665597 | 60102 | kwl 4
1665656 | 60104 | kwl 4
1665785 | 60104 | kwl 4
1666047 | 60105 | kwl 4
1666056 | 60105 | kwl 4
1666058 | 60105 | kwl 4
1666062 | 60105 | kwl 4
1666104 | 60105 | kwl 4
1666138 | 60105 | kwl 4
1666176 | 60105 | kwl 4
1666296 | 60605 | kwl 4
1666304 | 60605 | kwl 4
1666333 | 60605 | kwl 4
1666343 | 60605 | kwl 4
1666519 | 60605 | kwl 4
1666521 | 60605 | kwl 4
1666523 | 60605 | kwl 4
1666525 | 60605 | kwl 4
1666655 | 60105 | kwl 4
1666744 | 60105 | kwl 4
1666991 | 60105 | kwl 4
1667414 | 60102 | kwl 4
1667422 | 60102 | kwl 4
1667434 | 60102 | kwl 4
1667535 | 60102 | kwl 4
1667636 | 60102 | kwl 4
1667800 | 60102 | kwl 4
1667802 | 60102 | kwl 4
1667857 | 60102 | kwl 4
1667923 | 60102 | kwl 4
1667927 | 60102 | kwl 4
1668080 | 60102 | kwl 4
1668099 | 60102 | kwl 4
1668134 | 60102 | kwl 4
1668153 | 60102 | kwl 4
1668368 | 60102 | kwl 4
1668433 | 60102 | kwl 4
1668521 | 60102 | kwl 4
1668533 | 60102 | kwl 4
1668595 | 60102 | kwl 4
1668640 | 60102 | kwl 4
1668681 | 60102 | kwl 4
1668712 | 60102 | kwl 4
1668838 | 60102 | kwl 4
1668842 | 60102 | kwl 4
1669023 | 60102 | kwl 4
1669027 | 60102 | kwl 4
1669037 | 60102 | kwl 4
1669050 | 60102 | kwl 4
1669087 | 60104 | kwl 4
1669247 | 60104 | kwl 4
1669631 | 60104 | kwl 4
1669735 | 60604 | kwl 4
1670176 | 60104 | kwl 4
1670409 | 60104 | kwl 4
1670894 | 60104 | kwl 4
1670896 | 60104 | kwl 4
1671127 | 60102 | kwl 4
1671129 | 60102 | kwl 4
1671214 | 60104 | kwl 4
1671324 | 60104 | kwl 4
1671448 | 60104 | kwl 4
1671717 | 60105 | kwl 4
1671740 | 60105 | kwl 4
1672046 | 60104 | kwl 4
1672604 | 60104 | kwl 4
1672614 | 60104 | kwl 4
1672683 | 60102 | kwl 4
1672687 | 60102 | kwl 4
1672740 | 60104 | kwl 4
1672785 | 60104 | kwl 4
1673120 | 60104 | kwl 4
1673124 | 60104 | kwl 4
1673395 | 60102 | kwl 4
1673428 | 60105 | kwl 5
1673783 | 60105 | kwl 5
1674024 | 60104 | kwl 4
1674536 | 60104 | kwl 4
1674551 | 60104 | kwl 4
1674564 | 60104 | kwl 4
1674920 | 60104 | kwl 4
1675022 | 60104 | kwl 4
1675034 | 60104 | kwl 4
1675213 | 60104 | kwl 4
1715660 | 60102 | kwl 4
1719271 | 60102 | kwl 4
1719326 | 60102 | kwl 4
1731104 | 60105 | kwl 5
1731150 | 60105 | kwl 5
1820172 | 60104 | kwl 4
1820182 | 60102 | kwl 4
1820199 | 60102 | kwl 4
1820203 | 60102 | kwl 4
1820205 | 60102 | kwl 4
1820233 | 60104 | kwl 4
1820251 | 60105 | kwl 4
1820253 | 60105 | kwl 4
1820257 | 60105 | kwl 4
1820261 | 60105 | kwl 4
1820265 | 60105 | kwl 4
1820269 | 60105 | kwl 4
1821013 | 60105 | kwl 4
1821015 | 60105 | kwl 4
1821019 | 60105 | kwl 4
1821023 | 60105 | kwl 4
1821027 | 60105 | kwl 4
1821043 | 60102 | kwl 4
1826641 | 60102 | kwl 4

# IfcFlowFitting: Var. DN, NLRS_50_PIF_Mapress-Cu Coupling Slip_Geberit:Var. DN:1823535
In: 00_Begane Grond
Type - Description: Coupler Slip Mapress Copper; PredefinedType: CONNECTOR; Material: Geberit_Plastic , Paint Finish, White, NLRS_h5_koper_DHP
Pset_ManufacturerTypeInformation - ArticleNumber: 62105; Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var. DN
Group: kwl 4

# IfcFlowFitting: Var. DN (6)
In: 00_Begane Grond
Type - Description: Mapress C-Steel Reducer wpe; PredefinedType: TRANSITION; Material: Geberit_Paint Finish,Red, Geberit_Mapress_C-Steel
Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var. DN
Name (NLRS_50_PIF_UN_Mapress-CSt verloopstuk insteekeind_Geberit:Var. DN:...) | ArticleNumber | Group
1803877 | 22305 | cv-a 6
1803987 | 22305 | cv-r 5
1804441 | 22309 | cv-r 5
1805570 | 22309 | cv-a 3
1806531 | 22309 | cv-r 3
1806563 | 22309 | cv-a 5

# IfcFlowFitting: Var. DN (11)
In: 00_Begane Grond
Type - Description: Reducer WPE Mapress Copper; PredefinedType: TRANSITION; Material: Geberit_Plastic , Paint Finish, White, NLRS_h5_koper_DHP
Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var. DN
Group: kwl 4
Name (NLRS_50_PIF_Mapress-Cu Reducer WPE_Geberit:Var. DN:...) | ArticleNumber
1664646 | 62309
1667212 | 62307
1667228 | 62307
1668668 | 62305
1669621 | 62309
1671159 | 62309
1672719 | 62309
1677716 | 62309
1817481 | 62309
1820284 | 62309
1821057 | 62309

# IfcFlowFitting: Var. DN (26)
In: 00_Begane Grond
Type - Description: T-piece Equal Mapress Copper; PredefinedType: JUNCTION; Material: Geberit_Plastic , Paint Finish, White, NLRS_h5_koper_DHP
Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var. DN
Group: kwl 4
Name (NLRS_50_PIF_Mapress-Cu T-piece equal_Geberit:Var. DN:...) | ArticleNumber
1662429 | 61005
1664695 | 61004
1664765 | 61002
1665341 | 61002
1665350 | 61002
1665364 | 61002
1665710 | 61004
1667081 | 61005
1667129 | 61005
1667361 | 61002
1667819 | 61002
1668029 | 61002
1668177 | 61004
1668493 | 61002
1668897 | 61002
1669155 | 61004
1669182 | 61004
1669201 | 61004
1669554 | 61005
1670067 | 61004
1671428 | 61004
1672778 | 61004
1821068 | 61002
1821070 | 61002
1821072 | 61002
1821074 | 61002

# IfcFlowFitting: Var. DN, NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1820297
In: 00_Begane Grond
Type - Description: T-piece Reduced Mapress Copper; PredefinedType: JUNCTION; Material: Aluminum, Anodized Red, Geberit_Plastic , Paint Finish, White, NLRS_h5_koper_DHP
Pset_ManufacturerTypeInformation - ArticleNumber: 0; Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var. DN
Group: kwl 4

# IfcFlowFitting: Var. DN (24)
In: 00_Begane Grond
Type - Description: T-piece Reduced Mapress Copper; PredefinedType: JUNCTION; Material: Geberit_Plastic , Paint Finish, White, NLRS_h5_koper_DHP
Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var. DN
Group: kwl 4
Name | ArticleNumber
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1663833 | 61261
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1664612 | 61259
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1665589 | 61256
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1667994 | 61256
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1668227 | 61256
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1668587 | 61256
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1668632 | 61256
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1668698 | 61259
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1669776 | 61261
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1671055 | 61256
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1671968 | 61261
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1672081 | 61261
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1672637 | 61256
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1673112 | 61261
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1673154 | 61259
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1674016 | 61261
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1674513 | 61261
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1715616 | 61259
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1719198 | 61259
NLRS_50_PIF_Mapress-Cu T-piece reduced(p2)_Geberit:Var. DN:1820271 | 61242
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1820280 | 61261
NLRS_50_PIF_Mapress-Cu T-piece reduced(p2)_Geberit:Var. DN:1820286 | 61242
NLRS_50_PIF_Mapress-Cu T-piece reduced(p3)_Geberit:Var. DN:1821053 | 61261
NLRS_50_PIF_Mapress-Cu T-piece reduced(p2)_Geberit:Var. DN:1821059 | 61242

# IfcFlowFitting: Var. DN 2 (5)
In: 00_Begane Grond
Type - Description: Bend Mepla; PredefinedType: BEND; Material: NLRS_n6_PVDF_Geberit
Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var. DN 2
Group: kwl 4
Name (NLRS_50_PIF_UN_Mepla bocht_Geberit:Var. DN 2:...) | ArticleNumber
1660961 | 627.271.00.5
1660977 | 627.271.00.5
1661035 | 627.271.00.5
1661149 | 627.271.00.5
1661524 | 625.271.00.5

# IfcFlowFitting: Var. DN 2 (3)
In: 00_Begane Grond
Type - Description: Branch Mepla; PredefinedType: JUNCTION; Material: NLRS_n6_PVDF_Geberit
Pset_ManufacturerTypeInformation - ArticleNumber: 627.321.00.5; Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var. DN 2
Group: kwl 4
Name (NLRS_50_PIF_UN_Mepla T-stuk_Geberit:Var. DN 2:...)
1661179
1661198
1661217

# IfcFlowFitting: Var. DN 2 (4)
In: 00_Begane Grond
Type - Description: Reducer Mepla; PredefinedType: TRANSITION; Material: NLRS_n6_PVDF_Geberit
Pset_ManufacturerTypeInformation - ArticleNumber: 625.653.00.5; Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var. DN 2
Group: kwl 4
Name (NLRS_50_PIF_UN_Mepla verloopstuk_Geberit:Var. DN 2:...)
1664512
1664514
1664516
1664518

# IfcFlowFitting: Var.DN (53)
In: 00_Begane Grond
Type - Description: Mapress C-Steel Bend; PredefinedType: BEND; Material: Geberit_Paint Finish,Red, Geberit_Mapress_C-Steel
Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var.DN
Name (NLRS_50_PIF_UN_Mapress-CSt bocht_Geberit:Var.DN:...) | ArticleNumber | Group
1800837 | 20105 | cv-r 5
1801112 | 20105 | cv-a 3
1801150 | 20105 | cv-r 5
1801298 | 20602 | cv-a 3
1801302 | 20102 | cv-a 3
1801453 | 20102 | cv-r 5
1801514 | 20602 | cv-a 3
1801518 | 20102 | cv-a 3
1801536 | 20602 | cv-a 3
1801540 | 20102 | cv-a 3
1801558 | 20602 | cv-a 3
1801562 | 20102 | cv-a 3
1801582 | 20602 | cv-a 3
1801586 | 20102 | cv-a 3
1801608 | 20102 | cv-a 3
1801743 | 20102 | cv-r 5
1801757 | 20102 | cv-r 5
1801771 | 20102 | cv-r 5
1803340 | 20102 | cv-r 5
1803977 | 20102 | cv-r 5
1804227 | 20105 | cv-a 3
1804349 | 20102 | cv-r 5
1805704 | 20602 | cv-a 3
1806150 | 20102 | cv-r 5
1806207 | 20102 | cv-a 6
1806217 | 20102 | cv-a 6
1806225 | 20102 | cv-a 6
1806413 | 20602 | cv-a 5
1806417 | 20102 | cv-a 5
1806423 | 20102 | cv-r 3
1806429 | 20602 | cv-a 5
1806433 | 20102 | cv-a 5
1806439 | 20602 | cv-a 5
1806443 | 20102 | cv-a 5
1806459 | 20602 | cv-a 5
1806463 | 20102 | cv-a 5
1806503 | 20102 | cv-r 3
1806509 | 20102 | cv-r 3
1806529 | 20102 | cv-r 3
1806835 | 20102 | cv-r 3
1806901 | 20602 | cv-a 5
1806905 | 20102 | cv-a 5
1807206 | 20104 | cv-r 3
1807342 | 20104 | cv-a 5
1807391 | 20104 | cv-a 5
1807425 | 20104 | cv-r 3
1807453 | 20104 | cv-a 5
1807487 | 20104 | cv-r 3
1807512 | 20104 | cv-r 3
1807541 | 20104 | cv-a 5
1817207 | 20104 | gas 2
1820449 | 20105 | kwl 4
1823537 | 20105 | kwl 4

# IfcFlowFitting: Var.DN (11)
In: 00_Begane Grond
Type - Description: Mapress C-Steel Bend WPE; PredefinedType: BEND; Material: Geberit_Paint Finish,Red, Geberit_Mapress_C-Steel
Pset_ManufacturerTypeInformation - ArticleNumber: 20702; Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var.DN
Name (NLRS_50_PIF_UN_Mapress-CSt bocht insteekeind _Geberit:Var.DN:...) | Group
1804606 | cv-a 3
1804871 | cv-a 3
1805114 | cv-a 3
1805346 | cv-a 3
1805503 | cv-a 3
1805946 | cv-a 3
1806537 | cv-a 5
1806543 | cv-a 5
1806549 | cv-a 5
1806555 | cv-a 5
1806561 | cv-a 5

# IfcFlowFitting: Var.DN (2)
In: 00_Begane Grond
Type - Description: Mapress C-Steel Coupler; PredefinedType: CONNECTOR; Material: Geberit_Paint Finish,Red, Geberit_Mapress_C-Steel
Pset_ManufacturerTypeInformation - ArticleNumber: 22004; Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var.DN
Name (NLRS_50_PIF_UN_Mapress-CSt koppelstuk_Geberit:Var.DN:...) | Group
1807052 | cv-r 3
1807250 | cv-a 5

# IfcFlowFitting: Var.DN (2)
In: 00_Begane Grond
Type - Description: Mapress C-Steel T-piece Equal; PredefinedType: JUNCTION; Material: Geberit_Paint Finish,Red, Geberit_Mapress_C-Steel
Pset_ManufacturerTypeInformation - ArticleNumber: 21005; Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var.DN
Group: kwl 4
Name (NLRS_50_PIF_UN_Mapress-CSt T-stuk gelijkzijdig_Geberit:Var.DN:...)
1792952
1817475

# IfcFlowFitting: Var.DN (22)
In: 00_Begane Grond
Type - Description: Mapress C-Steel T-piece Reduced; PredefinedType: JUNCTION; Material: Geberit_Paint Finish,Red, Geberit_Mapress_C-Steel
Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Pset_DistributionFlowElementCommon - Reference: Var.DN
Name (NLRS_50_PIF_UN_Mapress-CSt T-stuk verlopend_Geberit:Var.DN:...) | ArticleNumber | Group
1801443 | 21209 | cv-r 5
1801733 | 21209 | cv-r 5
1801747 | 21209 | cv-r 5
1801761 | 21209 | cv-r 5
1803967 | 21206 | cv-r 5
1804339 | 21209 | cv-r 5
1804596 | 21209 | cv-a 3
1804861 | 21209 | cv-a 3
1805104 | 21209 | cv-a 3
1805336 | 21209 | cv-a 3
1805493 | 21209 | cv-a 3
1805950 | 21206 | cv-a 3
1806419 | 21209 | cv-r 3
1806499 | 21209 | cv-r 3
1806505 | 21209 | cv-r 3
1806525 | 21209 | cv-r 3
1806533 | 21209 | cv-a 5
1806539 | 21209 | cv-a 5
1806545 | 21209 | cv-a 5
1806551 | 21209 | cv-a 5
1806557 | 21209 | cv-a 5
1806842 | 21209 | cv-r 3

# IfcFlowFitting: gladde_bocht verzinkt_staal (143)
In: 00_Begane Grond
Type - Description: Rond - bochtstuk, radius 100 of D of 1,5xD; PredefinedType: BEND; Classification: 3A(57.55) (Uniformat); Material: NLRS_A_Naadloos stalen buis
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: gladde_bocht verzinkt_staal
Name (NLRS_57_DUF_UN_rond bocht_Luka:gladde_bocht verzinkt_staal:...) | Group
1564066 | lu-t 2
1572961 | lu-t 2
1586967 | lu-r 1
1587535 | lu-r 1
1587720 | lu-r 1
1587807 | lu-r 1
1587809 | lu-r 1
1588272 | lu-r 1
1588287 | lu-r 1
1588502 | lu-r 1
1588654 | lu-r 1
1588668 | lu-r 1
1588811 | lu-r 1
1588839 | lu-r 1
1588901 | lu-r 1
1588906 | lu-r 1
1589190 | lu-r 1
1589337 | lu-r 1
1589385 | lu-r 1
1589605 | lu-r 1
1589956 | lu-r 1
1590173 | lu-r 1
1590339 | lu-r 1
1590366 | lu-r 1
1590387 | lu-r 1
1590408 | lu-r 1
1591279 | lu-r 1
1591476 | lu-r 1
1591663 | lu-r 1
1591746 | lu-r 1
1592896 | lu-r 1
1594618 | lu-t 1
1594622 | lu-t 1
1594637 | lu-t 1
1594647 | lu-t 1
1594852 | lu-r 1
1595078 | lu-r 1
1595088 | lu-r 1
1595090 | lu-r 1
1595092 | lu-r 1
1595094 | lu-r 1
1595096 | lu-r 1
1595475 | lu-r 1
1596888 | lu-t 1
1596999 | lu-t 1
1597003 | lu-t 1
1598587 | lu-r 1
1598591 | lu-r 1
1598785 | lu-t 1
1598801 | lu-t 1
1603416 | lu-r 1
1604218 | lu-t 3
1604353 | lu-t 3
1604364 | lu-t 3
1605881 | lu-t 3
1623040 | lu-r 4
1623794 | lu-r 4
1625045 | lu-r 4
1626701 | lu-t 6
1627392 | lu-t 6
1627424 | lu-t 6
1627775 | lu-t 6
1627786 | lu-t 6
1627852 | lu-t 6
1627938 | lu-t 6
1627940 | lu-t 6
1628417 | lu-r 4
1628697 | lu-r 4
1628839 | lu-r 4
1628874 | lu-r 4
1629676 | lu-r 4
1629856 | lu-r 4
1632314 | lu-t 6
1632390 | lu-r 4
1632466 | lu-r 4
1632764 | lu-t 6
1632979 | lu-r 4
1633302 | lu-t 6
1633343 | lu-t 6
1633458 | lu-r 4
1633469 | lu-r 4
1633628 | lu-t 1
1639237 | lu-r 4
1646377 | lu-t 6
1646398 | lu-r 4
1684534 | lu-t 1
1684536 | lu-t 1
1684588 | lu-r 1
1711560 | lu-t 1
1711608 | lu-r 1
1711612 | lu-r 1
1711892 | bla 6
1722704 | afb 3
1722708 | afb 3
1722837 | afb 3
1722918 | afb 3
1723215 | afb 5
1723496 | afb 5
1723919 | bla 6
1723956 | bla 6
1724061 | bla 6
1724063 | bla 6
1724494 | afb 5
1724825 | afb 5
1724827 | afb 5
1731692 | afb 3
1731694 | afb 3
1741521 | lu-t 3
1741732 | lu-t 3
1742362 | lu-t 3
1742606 | lu-t 3
1742752 | lu-t 3
1743459 | lu-t 3
1752679 | lu-t 9
1756344 | lu-t 9
1756348 | lu-t 9
1756448 | lu-t 9
1756688 | lu-t 9
1757083 | lu-t 9
1786742 | lu-r 7
1787452 | lu-r 7
1787573 | lu-r 7
1787644 | lu-r 7
1787671 | lu-r 7
1791222 | lu-r 7
1794261 | afb 1
1794372 | lu-r 7
1795544 | lu-r 7
1799289 | afb 7
1813794 | lu-r 9
1813803 | lu-r 9
1813910 | lu-r 9
1814586 | lu-r 9
1816542 | lu-r 9
1817016 | lu-r 9
1817032 | lu-r 9
1817036 | lu-r 9
1817040 | lu-r 9
1817044 | lu-r 9
1817048 | lu-r 9
1817057 | lu-r 9
1817068 | lu-r 9
1817072 | lu-r 9

# IfcFlowFitting: mof - mof (88)
Type - Description: Wadal PVC Bend; PredefinedType: BEND; Material: PVC - U, Grey, RAL7100
Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: mof - mof
Name (NLRS_52_PIF_UN_Wadal bocht_PVC_Wavin:mof - mof:...) | In | ArticleNumber | Group
1487483 | 00_Begane Grond | 3101207009 | vwa 3
1544394 | -1_Kruipruimte | 3101212004 | vwa 5
1544400 | -1_Kruipruimte | 3101212004 | vwa 5
1544435 | -1_Kruipruimte | 3101211009 | vwa 5
1544794 | -1_Kruipruimte | 3101211009 | vwa 5
1545309 | -1_Kruipruimte | 3101211009 | vwa 5
1546477 | -1_Kruipruimte | 3101211009 | vwa 5
1546667 | -1_Kruipruimte | 3101211009 | vwa 5
1547110 | -1_Kruipruimte | 3101211009 | vwa 5
1547248 | -1_Kruipruimte | 3101211009 | vwa 5
1547400 | -1_Kruipruimte | 3101211009 | vwa 5
1547577 | -1_Kruipruimte | 3101211009 | vwa 5
1547844 | -1_Kruipruimte | 3101211009 | vwa 5
1548026 | -1_Kruipruimte | 3101211009 | vwa 5
1548351 | -1_Kruipruimte | 3101211009 | ontl 1
1548388 | -1_Kruipruimte | 3101211009 | ontl 1
1548951 | -1_Kruipruimte | 3101205009 | vwa 5
1549508 | -1_Kruipruimte | 3101205009 | vwa 5
1550261 | -1_Kruipruimte | 3101207009 | vwa 5
1550312 | -1_Kruipruimte | 3101207009 | vwa 5
1550348 | -1_Kruipruimte | 3101207009 | vwa 5
1550861 | -1_Kruipruimte | 3101207009 | vwa 5
1551805 | -1_Kruipruimte | 3101207009 | vwa 5
1552374 | -1_Kruipruimte | 3101211009 | vwa 5
1552744 | -1_Kruipruimte | 3101211009 | vwa 5
1552929 | -1_Kruipruimte | 3101211009 | vwa 5
1553036 | -1_Kruipruimte | 3101211009 | vwa 5
1553257 | -1_Kruipruimte | 3101211004 | vwa 5
1553289 | -1_Kruipruimte | 3101211009 | vwa 5
1553661 | -1_Kruipruimte | 3101205009 | vwa 5
1554120 | -1_Kruipruimte | 3101207009 | vwa 5
1554150 | -1_Kruipruimte | 3101207009 | vwa 5
1554180 | -1_Kruipruimte | 3101207009 | vwa 5
1554962 | -1_Kruipruimte | 3101207009 | vwa 5
1555521 | -1_Kruipruimte | 3101207009 | vwa 3
1555774 | -1_Kruipruimte | 3101211009 | vwa 2
1556605 | -1_Kruipruimte | 3101207009 | vwa 2
1556808 | -1_Kruipruimte | 3101211009 | vwa 2
1557253 | -1_Kruipruimte | 3101207009 | vwa 2
1558591 | -1_Kruipruimte | 3101211009 | ontl 2
1558621 | -1_Kruipruimte | 3101211009 | ontl 2
1559087 | -1_Kruipruimte | 3101207009 | ontl 1
1560258 | -1_Kruipruimte | 3101211009 | hwa 1
1560652 | -1_Kruipruimte | 3101211009 | hwa 7
1560654 | -1_Kruipruimte | 3101211009 | hwa 7
1560658 | -1_Kruipruimte | 3101211009 | hwa 1
1560660 | -1_Kruipruimte | 3101211009 | hwa 1
1560662 | -1_Kruipruimte | 3101211009 | hwa 1
1560664 | -1_Kruipruimte | 3101211009 | hwa 1
1560666 | -1_Kruipruimte | 3101211009 | hwa 1
1560668 | -1_Kruipruimte | 3101211009 | hwa 1
1560670 | -1_Kruipruimte | 3101211009 | hwa 1
1560672 | -1_Kruipruimte | 3101211009 | hwa 1
1560682 | -1_Kruipruimte | 3101211009 | hwa 1
1560692 | -1_Kruipruimte | 3101211009 | hwa 1
1560694 | -1_Kruipruimte | 3101211009 | hwa 1
1561942 | -1_Kruipruimte | 3101211009 | hwa 2
1562274 | -1_Kruipruimte | 3101211009 | hwa 2
1562314 | -1_Kruipruimte | 3101211009 | hwa 2
1562369 | -1_Kruipruimte | 3101211009 | hwa 2
1562399 | -1_Kruipruimte | 3101211009 | hwa 2
1562433 | -1_Kruipruimte | 3101211009 | hwa 2
1562508 | -1_Kruipruimte | 3101211009 | hwa 2
1562615 | -1_Kruipruimte | 3101211009 | hwa 2
1562694 | -1_Kruipruimte | 3101211009 | hwa 2
1713367 | -1_Kruipruimte | 3101207009 | vwa 5
1714071 | -1_Kruipruimte | 3101207009 | vwa 5
1715047 | -1_Kruipruimte | 3101207009 | vwa 5
1715326 | -1_Kruipruimte | 3101207009 | vwa 5
1715512 | -1_Kruipruimte | 3101207009 | vwa 1
1715814 | 00_Begane Grond | 3101207004 | hwa 1
1716023 | 00_Begane Grond | 3101207004 | hwa 1
1717552 | -1_Kruipruimte | 3101207009 | hwa 1
1717556 | 00_Begane Grond | 3101207004 | hwa 1
1717722 | -1_Kruipruimte | 3101207009 | hwa 1
1717726 | 00_Begane Grond | 3101207004 | hwa 1
1718926 | -1_Kruipruimte | 3101207009 | vwa 1
1793205 | 00_Begane Grond | 3101211009 | vwa 6
1793317 | 00_Begane Grond | 3101211009 | vwa 6
1793701 | 00_Begane Grond | 3101205004 | vwa 6
1793779 | 00_Begane Grond | 3101205009 | vwa 6
1794179 | 00_Begane Grond | 3101207009 | vwa 7
1818229 | 00_Begane Grond | 3101211009 | vwa 8
1818380 | 00_Begane Grond | 3101211009 | vwa 9
1818394 | 00_Begane Grond | 3101211009 | vwa 10
1818410 | 00_Begane Grond | 3101211009 | vwa 11
1818609 | 00_Begane Grond | 3101207009 | vwa 12
1818698 | 00_Begane Grond | 3101207009 | vwa 13

# IfcFlowFitting: mof - mof (3)
In: 00_Begane Grond
Type - Description: Wadal PVC Solv.Cement Coupler; PredefinedType: CONNECTOR; Material: PVC - U, Grey, RAL7100
Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: mof - mof
Name (NLRS_52_PIF_UN_Wadal lijmmof_PVC_Wavin:mof - mof:...) | ArticleNumber | Group
1482847 | 3100012000 | vwa 1
1486290 | 3100012000 | vwa 2
1487094 | 3100007000 | vwa 3

# IfcFlowFitting: mof - mof (21)
Type - Material: PVC - U, Grey, RAL7100
Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: mof - mof
Name (NLRS_52_PIF_UN_Wadal bocht 2x45_PVC_Wavin:mof - mof:...) | In | Group
1487141 | 00_Begane Grond | vwa 3
1487149 | 00_Begane Grond | vwa 3
1544422 | -1_Kruipruimte | vwa 5
1547558 | -1_Kruipruimte | vwa 5
1547817 | -1_Kruipruimte | vwa 5
1547999 | -1_Kruipruimte | vwa 5
1551458 | -1_Kruipruimte | vwa 5
1551682 | -1_Kruipruimte | vwa 5
1552342 | -1_Kruipruimte | vwa 5
1552354 | -1_Kruipruimte | vwa 5
1556531 | -1_Kruipruimte | vwa 2
1557058 | -1_Kruipruimte | vwa 2
1558485 | -1_Kruipruimte | vwa 2
1560529 | -1_Kruipruimte | hwa 1
1561898 | -1_Kruipruimte | hwa 2
1561946 | -1_Kruipruimte | hwa 2
1717062 | -1_Kruipruimte | hwa 1
1717569 | -1_Kruipruimte | hwa 1
1793184 | 00_Begane Grond | vwa 6
1818574 | 00_Begane Grond | vwa 12
1818694 | 00_Begane Grond | vwa 13

# IfcFlowFitting: mof - spie, NLRS_52_PIF_UN_Wadal bocht_PVC_Wavin:mof - spie:1718761
In: 00_Begane Grond
Type - Description: Wadal PVC Bend; PredefinedType: BEND; Material: PVC - U, Grey, RAL7100
Pset_ManufacturerTypeInformation - ArticleNumber: 3101112009; Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: mof - spie
Group: vwa 1

# IfcFlowFitting: spie (5)
In: 00_Begane Grond
Type - Description: Wadal PVC Cap; PredefinedType: USERDEFINED; Material: PVC - U, Grey, RAL7100
Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: spie
Name (NLRS_52_PIF_UN_Wadal eindkap_PVC_Wavin:spie:...) | ArticleNumber | Group
1478989 | 3105107000 | vwa 1
1479059 | 3105107000
1479101 | 3105104000 | vwa 3
1479176 | 3105104000 | vwa 4
1543724 | 3105107000 | vwa 5

# IfcFlowFitting: stromend ri=150 (19)
In: 00_Begane Grond
Type - Description: Rechthoekig - verlopende bocht; PredefinedType: BEND; Classification: 57.5 (Uniformat); Material: NLRS_A_staal Sendzimir verzinkt
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: stromend ri=150
Name (NLRS_57_DUF_UN_rechth verloopbocht-a_Luka:stromend ri=150:...) | Group
1611922 | lu-r 3
1612015 | lu-r 3
1613160 | lu-t 4
1614375 | lu-t 4
1614490 | lu-t 4
1615955 | lu-t 4
1616137 | lu-t 4
1632287 | lu-t 4
1687962 | lu-t 2
1687995 | lu-t 2
1688425 | lu-t 2
1688446 | lu-t 2
1688530 | lu-t 2
1688547 | lu-t 2
1752749 | lu-t 2
1753154 | lu-t 2
1753651 | lu-t 2
1754567 | lu-t 2
1754580 | lu-t 2

# IfcFlowFitting: stromend ri=150 2 (11)
In: 00_Begane Grond
Type - Description: Rechthoekig - verlopende bocht; PredefinedType: BEND; Classification: 57.5 (Uniformat); Material: NLRS_A_staal Sendzimir verzinkt
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_DistributionFlowElementCommon - Reference: stromend ri=150 2
Name (NLRS_57_DUF_UN_rechth verloopbocht-a_Luka:stromend ri=150 2:...) | Group
1608623 | bla 6
1726971 | bla 6
1748956 | afb 4
1749347 | bla 5
1758620 | afb 6
1760566 | bla 4
1760982 | afb 6
1765794 | bla 4
1766301 | afb 6
1766324 | afb 6
1766472 | afb 6

# IfcFlowFitting: var. (geneste versie) (103)
Type - Description: Wadal PVC Bend; PredefinedType: BEND; Material: PVC - U, Grey, RAL7100
Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: var. (geneste versie)
Name (NLRS_52_PIF_UN_Z_Wadal bocht-SH_PVC_Wavin:var. (geneste versie):...) | In | ArticleNumber
1545275 | -1_Kruipruimte | 3101111004
1545353 | -1_Kruipruimte | 3101111004
1545375 | -1_Kruipruimte | 3101211004
1545377 | -1_Kruipruimte | 3101111004
1546930 | -1_Kruipruimte | 3101111004
1547072 | -1_Kruipruimte | 3101111004
1547212 | -1_Kruipruimte | 3101111004
1547303 | -1_Kruipruimte | 3101111004
1547326 | -1_Kruipruimte | 3101111004
1547439 | -1_Kruipruimte | 3101111004
1547523 | -1_Kruipruimte | 3101111004
1547743 | -1_Kruipruimte | 3101211004
1547745 | -1_Kruipruimte | 3101111004
1547860 | -1_Kruipruimte | 3101211004
1547862 | -1_Kruipruimte | 3101111004
1547905 | -1_Kruipruimte | 3101111004
1548042 | -1_Kruipruimte | 3101211004
1548044 | -1_Kruipruimte | 3101111004
1548087 | -1_Kruipruimte | 3101111004
1548909 | -1_Kruipruimte | 3101105004
1549471 | -1_Kruipruimte | 3101105004
1550760 | -1_Kruipruimte | 3101107004
1550819 | -1_Kruipruimte | 3101107004
1551342 | -1_Kruipruimte | 3101107004
1551476 | -1_Kruipruimte | 3101207004
1551478 | -1_Kruipruimte | 3101107004
1551739 | -1_Kruipruimte | 3101107004
1551763 | -1_Kruipruimte | 3101207004
1551765 | -1_Kruipruimte | 3101107004
1552123 | -1_Kruipruimte | 3101111004
1552539 | -1_Kruipruimte | 3101211004
1552541 | -1_Kruipruimte | 3101111004
1552581 | -1_Kruipruimte | 3101211004
1552583 | -1_Kruipruimte | 3101111004
1552708 | -1_Kruipruimte | 3101111004
1552891 | -1_Kruipruimte | 3101111004
1553075 | -1_Kruipruimte | 3101111004
1553595 | -1_Kruipruimte | 3101105004
1554524 | -1_Kruipruimte | 3101107004
1554576 | -1_Kruipruimte | 3101107004
1554625 | -1_Kruipruimte | 3101107004
1555075 | -1_Kruipruimte | 3101107004
1555586 | 00_Begane Grond | 3101107004
1555633 | 00_Begane Grond | 3101207004
1555635 | 00_Begane Grond | 3101107004
1555639 | 00_Begane Grond | 3101207004
1555641 | 00_Begane Grond | 3101107004
1556533 | -1_Kruipruimte | 3101211004
1556535 | -1_Kruipruimte | 3101111004
1556679 | -1_Kruipruimte | 3101107004
1557096 | -1_Kruipruimte | 3101111004
1557136 | -1_Kruipruimte | 3101211004
1557138 | -1_Kruipruimte | 3101111004
1557292 | -1_Kruipruimte | 3101107004
1558497 | -1_Kruipruimte | 3101211004
1558499 | -1_Kruipruimte | 3101111004
1561278 | -1_Kruipruimte | 3101111004
1561285 | -1_Kruipruimte | 3101111004
1561289 | -1_Kruipruimte | 3101111004
1561293 | -1_Kruipruimte | 3101111004
1561301 | -1_Kruipruimte | 3101111004
1561305 | -1_Kruipruimte | 3101111004
1561309 | -1_Kruipruimte | 3101111004
1561313 | -1_Kruipruimte | 3101111004
1561317 | -1_Kruipruimte | 3101111004
1561337 | -1_Kruipruimte | 3101111004
1561409 | -1_Kruipruimte | 3101111004
1561429 | -1_Kruipruimte | 3101111004
1561433 | -1_Kruipruimte | 3101111004
1561976 | -1_Kruipruimte | 3101211004
1561978 | -1_Kruipruimte | 3101111004
1561982 | -1_Kruipruimte | 3101211004
1561984 | -1_Kruipruimte | 3101111004
1562288 | -1_Kruipruimte | 3101211004
1562290 | -1_Kruipruimte | 3101111004
1562351 | -1_Kruipruimte | 3101111004
1562381 | -1_Kruipruimte | 3101111004
1562411 | -1_Kruipruimte | 3101111004
1562445 | -1_Kruipruimte | 3101111004
1562465 | -1_Kruipruimte | 3101111004
1562524 | -1_Kruipruimte | 3101111004
1562627 | -1_Kruipruimte | 3101111004
1562706 | -1_Kruipruimte | 3101111004
1713331 | -1_Kruipruimte | 3101107004
1714119 | -1_Kruipruimte | 3101107004
1715012 | -1_Kruipruimte | 3101107004
1715374 | -1_Kruipruimte | 3101107004
1717460 | -1_Kruipruimte | 3101107004
1717581 | -1_Kruipruimte | 3101107004
1717761 | -1_Kruipruimte | 3101212004
1717763 | -1_Kruipruimte | 3101112004
1717773 | -1_Kruipruimte | 3101212004
1717775 | -1_Kruipruimte | 3101112004
1718374 | -1_Kruipruimte | 3101112004
1718380 | -1_Kruipruimte | 3101112004
1793219 | 00_Begane Grond | 3101211004
1793221 | 00_Begane Grond | 3101111004
1793329 | 00_Begane Grond | 3101111004
1818796 | 00_Begane Grond | 3101107004
1822129 | 00_Begane Grond | 3101207004
1822131 | 00_Begane Grond | 3101107004
1822141 | 00_Begane Grond | 3101207004
1822143 | 00_Begane Grond | 3101107004

# IfcFlowFitting: var. (geneste versie) (72)
Type - Description: Wadal PVC Branch; PredefinedType: JUNCTION; Material: PVC - U, Grey, RAL7100
Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: var. (geneste versie)
Name (NLRS_52_PIF_UN_Z_Wadal T-stuk-SH_PVC_Wavin:var. (geneste versie):...) | In | ArticleNumber
1478910 | 00_Begane Grond | 3102212009
1479055 | 00_Begane Grond | 3102212009
1479097 | 00_Begane Grond | 3102207009
1479172 | 00_Begane Grond | 3102207009
1487344 | 00_Begane Grond | 3102207004
1543720 | 00_Begane Grond | 3102212009
1544388 | -1_Kruipruimte | 3102212009
1544769 | -1_Kruipruimte | 3102211004
1545081 | -1_Kruipruimte | 3102211004
1545124 | -1_Kruipruimte | 3102212114
1545534 | -1_Kruipruimte | 3102212114
1546595 | -1_Kruipruimte | 3102211004
1547024 | -1_Kruipruimte | 3102211004
1547164 | -1_Kruipruimte | 3102211004
1547382 | -1_Kruipruimte | 3102211004
1547486 | -1_Kruipruimte | 3102211004
1547803 | -1_Kruipruimte | 3102211004
1547985 | -1_Kruipruimte | 3102211004
1548732 | -1_Kruipruimte | 3102211054
1549469 | -1_Kruipruimte | 3102212054
1549802 | -1_Kruipruimte | 3102211074
1550006 | -1_Kruipruimte | 3102207004
1550637 | -1_Kruipruimte | 3102211074
1551655 | -1_Kruipruimte | 3102211074
1552066 | -1_Kruipruimte | 3102212114
1552641 | -1_Kruipruimte | 3102211004
1552832 | -1_Kruipruimte | 3102211004
1552983 | -1_Kruipruimte | 3102211004
1553147 | -1_Kruipruimte | 3102211004
1553493 | -1_Kruipruimte | 3102212054
1553837 | -1_Kruipruimte | 3102212074
1553872 | -1_Kruipruimte | 3102212074
1554000 | -1_Kruipruimte | 3102212074
1554901 | -1_Kruipruimte | 3102212074
1556591 | -1_Kruipruimte | 3102211074
1557048 | -1_Kruipruimte | 3102211004
1557212 | -1_Kruipruimte | 3102211074
1558540 | -1_Kruipruimte | 3102211009
1558751 | -1_Kruipruimte | 3102207009
1559060 | -1_Kruipruimte | 3102211079
1560558 | -1_Kruipruimte | 3102212114
1560566 | -1_Kruipruimte | 3102212114
1560578 | -1_Kruipruimte | 3102216114
1560584 | -1_Kruipruimte | 3102216114
1560590 | -1_Kruipruimte | 3102216114
1560596 | -1_Kruipruimte | 3102216114
1560602 | -1_Kruipruimte | 3102216114
1560608 | -1_Kruipruimte | 3102216114
1560614 | -1_Kruipruimte | 3102216114
1560620 | -1_Kruipruimte | 3102216114
1560632 | -1_Kruipruimte | 3102216114
1560638 | -1_Kruipruimte | 3102216114
1560690 | -1_Kruipruimte | 3102212114
1562238 | -1_Kruipruimte | 3102211004
1562312 | -1_Kruipruimte | 3102211004
1562367 | -1_Kruipruimte | 3102211004
1562397 | -1_Kruipruimte | 3102211004
1562431 | -1_Kruipruimte | 3102211004
1562504 | -1_Kruipruimte | 3102211004
1562611 | -1_Kruipruimte | 3102211004
1562690 | -1_Kruipruimte | 3102211004
1713329 | -1_Kruipruimte | 3102212074
1713996 | -1_Kruipruimte | 3102212074
1714957 | -1_Kruipruimte | 3102212074
1715201 | -1_Kruipruimte | 3102211074
1717369 | -1_Kruipruimte | 3102212004
1717408 | -1_Kruipruimte | 3102212074
1717579 | -1_Kruipruimte | 3102212074
1718334 | -1_Kruipruimte | 3102212004
1793283 | 00_Begane Grond | 3102211004
1793682 | 00_Begane Grond | 3102211054
1818778 | 00_Begane Grond | 3102207004

# IfcFlowFitting: var. (geneste versie) (6)
Type - Description: Wadal PVC Reducer bush; PredefinedType: TRANSITION; Material: PVC - U, Grey, RAL7100
Pset_ManufacturerTypeInformation - Manufacturer: Wavin
Pset_DistributionFlowElementCommon - Reference: var. (geneste versie)
Name (NLRS_52_PIF_UN_Z_Wadal verloopring-SH1_PVC_Wavin:var. (geneste versie):...) | In | ArticleNumber
1486233 | 00_Begane Grond | 3104212110
1549729 | -1_Kruipruimte | 3104212110
1551303 | -1_Kruipruimte | 3104211070
1561354 | -1_Kruipruimte | 3104216120
1561426 | -1_Kruipruimte | 3104212110
1718920 | 00_Begane Grond | 3104212070

# IfcFlowFitting: verzinkt_staal (4)
In: 00_Begane Grond
