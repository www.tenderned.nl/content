Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcFlowSegment: Pipe Types:Onbepaald PVC_Gladde buis 4m (39)
Name (Pipe Types:Onbepaald PVC_Gladde buis 4m:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
2947031 | V00 | 4750.72 | -85.2123 | M524 14
2948360 | V00 | 3403.75 | 2882.86 | M524 61
2948449 | V01 | 109.705 | 2772.06 | M524 61
2948463 | V00 | 2824.86 | -58 | M524 61
2948507 | V01 | 2416 | 2772.06 | M524 61
2948539 | V01 | 229.811 | 2772.06 | M524 61
2948973 | V01 | 1681.52 | 2828.81 | M524 61
2948992 | V01 | 1101.61 | 2772.06 | M524 61
2949103 | V01 | 587.599 | 2906.2 | M524 61
2949111 | V01 | 4.98781 | 3525.61 | M524 61
5032880 | V00 | 642 | 4677.86 | M524 14 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0; Pset_FlowSegmentPipeSegment - Color: 0
5032904 | V00 | 1271 | 5218.66 | M524 14 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0; Pset_FlowSegmentPipeSegment - Color: 0

# IfcFlowSegment: Pipe Types:Onbepaald PVC_Ultra-3 4m (29)
Pset_DistributionFlowElementCommon - Reference: Onbepaald PVC_Ultra-3 4m; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipes
Name (Pipe Types:Onbepaald PVC_Ultra-3 4m:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
2515965 | V99 | 247.884 | -1534.49 | M524 5
2516110 | V99 | 249.601 | -1201.8 | M524 43
2516114 | V99 | 1586.89 | -1201.8 | M524 43
2516150 | V99 | 174.545 | -1184.5 | M524 13
2516160 | V99 | 2963.43 | -1184.5 | M524 13
2516171 | V99 | 1034.01 | -1534.5 | M524 57
2516175 | V99 | 4868.76 | -1534.5 | M524 57
2516179 | V99 | 589.274 | -1512 | M524 57
2516183 | V99 | 1805.1 | -1534.5 | M524 57
2516220 | V99 | 2947.02 | -1534.5 | M524 57
2516228 | V99 | 808.778 | -1534.5 | M524 57
2516234 | V99 | 5055.22 | -1534.5 | M524 57
2516238 | V99 | 1828.22 | -1534.5 | M524 57
2516242 | V99 | 925.139 | -1512 | M524 57
2516310 | V99 | 197.248 | -1534.5 | M524 57
2516318 | V99 | 3549.95 | -1534.5 | M524 57
2516330 | V99 | 634.908 | -1534.49 | M524 41
2516367 | V99 | 453.941 | -1520.5 | M524 23
2516371 | V99 | 733.122 | -1551.8 | M524 23
2516375 | V99 | 88 | -1520.5 | M524 23
2516412 | V99 | 3863.36 | -1551.8 | M524 23
2516416 | V99 | 911.216 | -1520.5 | M524 23
2516452 | V99 | 1034.99 | -1520.5 | M524 23
2516456 | V99 | 443.307 | -1551.8 | M524 23
2516499 | V99 | 4040.9 | -1551.8 | M524 23
2516507 | V99 | 625.658 | -1551.8 | M524 23
2944145 | V00 | 300 | 2850 | M524 62
2944643 | V00 | 1160 | -1110 | M524 13
2945066 | V99 | 2060 | -1460 | M524 57

# IfcFlowSegment: Pipe Types:Staal_Draadpijp gemenied (7)
In: V00
Pset_DistributionFlowElementCommon - Reference: Staal_Draadpijp gemenied; sets with these values: 2
Pset_ProductRequirements - Category: Pipes
Name (Pipe Types:Staal_Draadpijp gemenied:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
4426552 | 198.478 | -79.3 | M561R 1
4430723 | 188.261 | -79.3 | M561R 2
4430728 | 322.279 | -26.5 | M561F 1
4430733 | 179.815 | -26.5 | M561F 1
4434887 | 174.393 | -79.3 | M561R 1
4434891 | 1729.93 | -26.5 | M561F 1
4434895 | 7591.69 | -26.5 | M561F 1

# IfcFlowSegment: Pipe Types:VSH XPress Koper_Koper (378)
Pset_DistributionFlowElementCommon - Reference: VSH XPress Koper_Koper; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: VSH
Pset_ProductRequirements - Category: Pipes
Name (Pipe Types:VSH XPress Koper_Koper:...) | In | Pset_ElementShading, Color = Pset_FlowSegmentDuctSegment, Color = Pset_FlowSegmentPipeSegment, Color | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
4956005 | V00 | 0 | 841.053 | 2365.1 | M5504 1
4957014 | V00 |  | 1467.94 | 2365.1 | M5504 1
4957278 | V00 | 0 | 2194.18 | 2365.1 | M5332R 1
4957418 | V00 | 0 | 2768 | 2310.1 | M533F 1
4957458 | V00 | 0 | 1427 | 2310.1 | M5503 1
4957468 | V00 | 0 | 286.138 | 2310.1 | M5503 1
4957500 | V00 | 0 | 1699.5 | 2310.1 | M5504 1
4958833 | V00 | 0 | 2041.4 | 2365.1 | M5332F 2
4958841 | V00 | 0 | 280.056 | 2161.48 | M5332F 2
4958863 | V00 | 0 | 280.056 | 2161.48 | M5332F 2
4958873 | V00 | 0 | 957.372 | 2365.1 | M5332F 2
4959150 | V00 | 0 | 280.056 | 2161.48 | M5332R 1
4959172 | V00 | 0 | 280.056 | 2161.48 | M5332R 1
4959307 | V00 | 0 | 280.056 | 2161.48 | M533F 1
4959331 | V00 | 0 | 280.056 | 2161.48 | M533F 1
4959748 | V00 | 0 | 2493.9 | 2365.1 | M5337F 1
4959758 | V00 | 0 | 280.056 | 2161.48 | M5337F 1
4959778 | V00 | 0 | 280.056 | 2161.48 | M5337F 1
4968865 | V00 | 0 | 423.019 | 2310.1 | M5504 1
4968922 | V00 | 0 | 987.511 | 2365.1 | M5503 1
4968947 | V00 | 0 | 1142.64 | 2365.1 | M5332F 2
4968966 | V00 | 0 | 1289.15 | 2365.1 | M5332R 1
4968985 | V00 | 0 | 1450.29 | 2365.1 | M533F 1
4968996 | V00 | 0 | 2352.4 | 2365.1 | M533F 1
4969015 | V00 | 0 | 1590.29 | 2365.1 | M5337F 1
4969036 | V00 | 0 | 1744.22 | 2365.1 | M5421 1
4969566 | V00 | 0 | 35.5 | 2365.1 | M5504 1
4969574 | V00 | 0 | 53.7817 | 2321.48 | M5504 1
4969679 | V00 | 0 | 28 | 2365.1 | M5503 1
4969716 | V00 | 0 | 53.7817 | 2321.48 | M5503 1
4969777 | V00 | 0 | 2592 | 2365.1 | M5421 1
4969785 | V00 | 0 | 280.056 | 2161.48 | M5421 1
4969920 | V00 | 0 | 280.056 | 2161.48 | M5421 1
4970237 | V00 |  | 1115.34 | 2400.1 | M5332F 2
4971155 | V00 | 0 | 53 | 2365.1 | M533F 1
4971165 | V00 | 0 | 53.7812 | 2321.48 | M533F 1
4971318 | V00 | 0 | 1618.32 | 2365.1 | M5503 1
4971910 | V00 | 0 | 283.961 | 2150.1 | M5332F 2
4971928 | V00 | 0 | 282.749 | 2150.1 | M5332R 1
4971950 | V00 | 0 | 279.533 | 2150.1 | M533F 1
4971970 | V00 | 0 | 279.745 | 2150.1 | M5337F 1
4971992 | V00 | 0 | 334.934 | 2150.1 | M5421 1
4972191 | V00 | 0 | 21.4975 | 2379.31 | M5332F 2
4972592 | V00 | 0 | 1261.85 | 2400.1 | M5332R 1
4972616 | V00 | 0 | 21.4975 | 2379.31 | M5332R 1
4972633 | V00 | 0 | 1375.68 | 2400.1 | M533F 1
4972659 | V00 | 0 | 1525.68 | 2400.1 | M5337F 1
4972712 | V00 | 0 | 1679.61 | 2400.1 | M5421 1
4972722 | V00 | 0 | 9.30986 | 2365.1 | M5421 1
4972723 | V00 | 0 | 25.4975 | 2376.48 | M5421 1
4972727 | V00 | 0 | 355.8 | 2365.1 | M5421 1
4972755 | V00 | 0 | 9.30986 | 2365.1 | M5337F 1
4972756 | V00 | 0 | 25.4975 | 2376.48 | M5337F 1
4972760 | V00 | 0 | 509.088 | 2365.1 | M5337F 1
4972798 | V00 | 0 | 9.30986 | 2365.1 | M533F 1
4972799 | V00 | 0 | 25.4975 | 2376.48 | M533F 1
4972803 | V00 | 0 | 660.8 | 2365.1 | M533F 1
4972895 | V00 | 0 | 9.30986 | 2365.1 | M533F 1
4972896 | V00 | 0 | 25.4975 | 2376.48 | M533F 1
4972900 | V00 | 0 | 588 | 2365.1 | M533F 1
4972936 | V00 |  | 249.034 | 2400.1 | M533F 1
4981210 | V00 | 0 | 28.4219 | 2400.1 | M533F 1
4981311 | V00 | 0 | 5104 | 2400.1 | M533F 2
4981360 | V00 | 0 | 2879.37 | 2400.1 | M533F 2
4981372 | V00 | 0 | 874 | 2400.1 | M533F 2
4981404 | V00 | 0 | 414 | 2400.1 | M533F 2
4981643 | V00 | 0 | 854 | 2436 | M533F 2
4981716 | V00 | 0 | 481.015 | 2365.1 | M5421 1
4981789 | V00 | 0 | 32.8848 | 2365.1 | M5421 1
4981977 | V00 | 0 | 805.8 | 2365.1 | M5332R 1
4982426 | V00 | 0 | 2608 | 2365.1 | M533F 1
4982442 | V00 | 0 | 236.183 | 2365.1 | M533F 3
4983016 | V00 | 0 | 2778 | 2365.1 | M5332F 2
4984730 | V00 | 0 | 242.261 | 2365.1 | M5332R 5
4985477 | V00 | 0 | 233.078 | 2365.1 | M5421 2
4994166 | V00 | 0 | 239.09 | 2365.1 | M5332F 2
4994304 | V00 | 0 | 5595.66 | 2365.1 | M5332R 4
4995141 | V00 | 0 | 2746.34 | 2365.1 | M533F 1
4995346 | V00 | 0 | 388 | 2436 | M5337F 1
4995384 | V00 | 0 | 5516.4 | 2840.1 | M5337F 1
4995502 | V00 | 0 | 423 | 2401 | M5332R 4
4995543 | V00 | 0 | 5476.28 | 2840.1 | M5332R 4
4995553 | V00 | 0 | 1416.4 | 2840.1 | M5332R 4
4995629 | V00 | 0 | 5527.58 | 2840.1 | M5332F 1
4995644 | V00 | 0 | 423 | 2401 | M5332F 1
4995683 | V00 | 0 | 5516.4 | 2840.1 | M5332R 1
4995694 | V00 | 0 | 423 | 2401 | M5332R 1
4995759 | V00 | 0 | 5526.4 | 2840.1 | M533F 1
4995770 | V00 | 0 | 423 | 2401 | M533F 1
4995776 | V00 | 0 | 2031.51 | 2840.1 | M533F 1
4995839 | V00 | 0 | 5516.4 | 2840.1 | M5421 1
4995856 | V00 | 0 | 423 | 2401 | M5421 1
4995862 | V00 | 0 | 1865.31 | 2840.1 | M5421 1
4995938 | V00 | 0 | 174.026 | 2400.1 | M533F 5
4996056 | V00 | 0 | 9.30986 | 2365.1 | M533F 1
4996057 | V00 | 0 | 25.4975 | 2376.48 | M533F 1
4996158 | V00 | 0 | 57.2533 | 2400.1 | M533F 1
4996169 | V00 | 0 | 929.342 | 2400.1 | M533F 1
4996188 | V00 | 0 | 133.301 | 2400.1 | M533F 1
4996241 | V00 | 0 | 1284 | 2400.1 | M533F 4
4996280 | V00 | 0 | 2498 | 2400.1 | M533F 4
4996294 | V00 | 0 | 374 | 2400.1 | M533F 4
4996326 | V00 | 0 | 380 | 2400.1 | M533F 4
4996939 | V00 | 0 | 3170.99 | 2840.1 | M5337F 1
4997017 | V00 | 0 | 62 | 2840.1 | M5332R 4
4997125 | V00 | 0 | 46.7107 | 2851.48 | M5332R 4
4997189 | V00 | 0 | 1587 | 2890.1 | M5332R 4
4997277 | V00 | 0 | 2373.76 | 2840.1 | M5332F 1
4997402 | V00 | 0 | 39.3997 | 2840.1 | M5332F 1
4997403 | V00 | 0 | 46.7107 | 2851.48 | M5332F 1
4997494 | V00 | 0 | 46.7107 | 2851.48 | M5332R 1
4997524 | V00 | 0 | 2207.56 | 2840.1 | M5332R 1
4997535 | V00 | 0 | 30.4964 | 2840.1 | M5332R 1
4997552 | V00 | 0 | 2316 | 2890.1 | M533F 1
4997598 | V00 | 0 | 46.7107 | 2851.48 | M533F 1
4997709 | V00 | 0 | 38.9043 | 2840.1 | M533F 1
4997745 | V00 | 0 | 2326 | 2890.1 | M5421 1
4997836 | V00 | 0 | 46.7107 | 2851.48 | M5421 1
4997859 | V00 | 0 | 77.6381 | 2840.1 | M5421 1
4997865 | V00 | 0 | 28.3619 | 2840.1 | M5421 1
4998008 | V00 | 0 | 2352 | 2890.1 | M5332R 1
4998036 | V00 | 0 | 520.647 | 2890.1 | M5421 1
4998066 | V00 | 0 | 680.647 | 2890.1 | M533F 1
4998110 | V00 | 0 | 48 | 2890.1 | M533F 1
4998164 | V00 | 0 | 46.7107 | 2851.48 | M533F 1
4998184 | V00 | 0 | 830.647 | 2890.1 | M5332R 1
4998225 | V00 | 0 | 43 | 2890.1 | M5332R 1
4998277 | V00 | 0 | 46.7107 | 2851.48 | M5332R 1
4998297 | V00 | 0 | 2371.7 | 2890.1 | M5332F 1
4998305 | V00 | 0 | 980.647 | 2890.1 | M5332F 1
4998441 | V00 | 0 | 245 | 2840.1 | M5337F 1
4998506 | V00 | 0 | 284 | 2840.1 | M5337F 1
4998517 | V00 | 0 | 2739.91 | 2840.1 | M5337F 1
4998545 | V00 | 0 | 48 | 2890.1 | M5332F 1
4998586 | V00 | 0 | 492 | 2840.1 | M5332F 1
4998595 | V00 | 0 | 46.7107 | 2851.48 | M5332F 1
4998736 | V00 | 0 | 289 | 2840.1 | M5332F 1
4998780 | V00 | 0 | 782 | 2840.1 | M5332R 1
4998919 | V00 | 0 | 439 | 2840.1 | M5332R 1
4998956 | V00 | 0 | 1057 | 2840.1 | M533F 1
4999015 | V00 | 0 | 589 | 2840.1 | M533F 1
4999178 | V00 | 0 | 37.2682 | 2840.1 | M5337F 1
4999196 | V00 | 0 | 1118 | 2840.1 | M5337F 1
4999206 | V00 | 0 | 780.787 | 2840.1 | M5337F 1
4999216 | V00 | 0 | 522 | 2840.1 | M5337F 1
4999342 | V00 | 0 | 3440.77 | 2840.1 | M5337F 1
4999411 | V00 | 0 | 6167.1 | 2840.1 | M5337F 1
4999421 | V00 | 0 | 540.888 | 2840.1 | M5337F 1
4999480 | V00 | 0 | 1410.9 | 2840.1 | M5337F 1
4999525 | V00 | 0 | 227.096 | 2840.1 | M533F 1
4999549 | V00 | 0 | 374.817 | 2840.1 | M5332R 1
4999600 | V00 | 0 | 524.275 | 2840.1 | M5332F 1
4999874 | V00 | 0 | 1064 | 2840.1 | M533F 1
4999884 | V00 | 0 | 67 | 2840.1 | M533F 1
4999892 | V00 | 0 | 373 | 2890.1 | M533F 1
4999977 | V00 | 0 | 46.7107 | 2851.48 | M533F 1
5000020 | V00 | 0 | 944 | 2840.1 | M5332R 1
5000030 | V00 | 0 | 52 | 2840.1 | M5332R 1
5000038 | V00 | 0 | 238 | 2890.1 | M5332R 1
5000095 | V00 | 0 | 46.7107 | 2851.48 | M5332R 1
5000125 | V00 | 0 | 214 | 2840.1 | M5332F 1
5000167 | V00 | 0 | 214 | 2840.1 | M5332F 1
5000210 | V00 | 0 | 2920 | 2840.1 | M5332F 1
5000262 | V00 | 0 | 52 | 2840.1 | M5332R 1
5000296 | V00 | 0 | 2780 | 2840.1 | M5332R 1
5000322 | V00 | 0 | 2924 | 2840.1 | M533F 1
5000332 | V00 | 0 | 57 | 2840.1 | M533F 1
5000340 | V00 | 0 | 383 | 2890.1 | M533F 1
5000406 | V00 | 0 | 46.7107 | 2851.48 | M533F 1
5000446 | V00 | 0 | 2904 | 2840.1 | M5332R 1
5000450 | V00 | 0 | 238 | 2890.1 | M5332R 1
5000461 | V00 | 0 | 46.7107 | 2851.48 | M5332R 1
5000493 | V00 | 0 | 2640 | 2840.1 | M533F 1
5000519 | V00 | 0 | 6692 | 2840.1 | M5421 1
5000834 | V00 |  | 2488.16 | 2840.1 | M533F 6
5000851 | V00 | 0 | 1414 | 2840.1 | M533F 6
5001142 | V00 | 0 | 2884 | 2840.1 | M5332F 1
5001201 | V00 | 0 | 790.4 | 2840.1 | M5332F 1
5001445 | V00 | 0 | 340 | 1190.1 | M5C01 1
5002118 | V01 | 0 | 404.608 | 6580.1 | M5332R 4
5002387 | Dak | 0 | 554 | 6580.1 | M5421 1
5002626 | Dak | 0 | 704 | 6580.1 | M533F 7
5002900 | Dak | 0 | 99.4187 | 6580.1 | M5332R 4
5003011 | Dak | 0 | 360.685 | 6580.1 | M5421 1
5003062 | Dak | 0 | 47.9859 | 6591.48 | M5421 1
5003510 | Dak | 0 | 2220.85 | 6631.03 | M5421 1
5003714 | Dak | 0 | 25.6926 | 6591.48 | M5332R 4
5003722 | Dak | 0 | 2379.55 | 6620.45 | M5332R 4
5004341 | V00 | 0 | 3638 | 2926 | M5332F 3
5004361 | V00 | 0 | 3638 | 2926 | M5332R 2
5004383 | V00 | 0 | 3638 | 2926 | M533F 7
5004403 | V00 | 0 | 3638 | 2926 | M5421 1
5004425 | V00 | 0 | 3638 | 2926 | M5332R 4
5004482 | Dak | 0 | 492.933 | 6580.1 | M5332R 4
5004745 | V00 | 0 | 3688 | 2876 | M5337F 1
5004891 | Dak | 0 | 3604.42 | 6580.1 | M5421 1
5004903 | Dak | 0 | 642.324 | 6580.1 | M5421 1
5004948 | Dak | 0 | 2012.9 | 6580.1 | M533F 7
5004956 | Dak | 0 | 792.324 | 6580.1 | M533F 7
5005448 | Dak | 0 | 1256.26 | 6639.07 | M5332R 4
5005524 | Dak | 0 | 48.0213 | 6594.31 | M5332R 4
5005531 | Dak | 0 | 1886.24 | 6580.1 | M5332R 4
5005820 | Dak | 0 | 103.645 | 6727.79 | M5332R 4
5006298 | Dak | 0 | 54.2937 | 6580.1 | M5332R 4
5006358 | Dak | 0 | 57 | 6580.1 | M5421 1
5006699 | Dak | 0 | 524 | 6728.93 | M5332R 4
5006763 | Dak | 0 | 104 | 6766.58 | M5332R 4
5006809 | Dak | 0 | 2154 | 6767.72 | M5332R 4
5007064 | Dak | 0 | 93.9997 | 6919.8 | M5332R 4
5007331 | Dak | 0 | 4982 | 6660.41 | M533F 7
5007444 | Dak | 0 | 1695.76 | 6580.1 | M5332R 4
5007570 | Dak | 0 | 77.2641 | 6595.58 | M533F 7
5007578 | Dak | 0 | 2237.05 | 6580.1 | M533F 7
5007804 | Dak | 0 | 1739.63 | 7009.7 | M533F 7
5007987 | Dak | 0 | 474 | 7009.7 | M533F 7
5008124 | Dak | 0 | 4662 | 6672.32 | M5332R 2
5008489 | Dak | 0 | 83.0482 | 6603.13 | M5332R 2
5008632 | Dak | 0 | 1775.19 | 6999.3 | M5332R 2
5008821 | Dak | 0 | 624 | 6999.3 | M5332R 2
5008871 | Dak | 0 | 2509.78 | 6580.1 | M5332R 2
5008879 | Dak | 0 | 952.324 | 6580.1 | M5332R 2
5009146 | Dak | 0 | 4355.67 | 6684.23 | M5332F 3
5009381 | Dak | 0 | 1803 | 6989.9 | M5332F 3
5009754 | Dak | 0 | 760.652 | 6990.18 | M5332F 3
5009777 | Dak | 0 | 98.8323 | 6603.13 | M5332F 3
5009796 | Dak | 0 | 2799.52 | 6580.1 | M5332F 3
5009806 | Dak | 0 | 1112.32 | 6580.1 | M5332F 3
5009896 | Dak | 0 | 519.866 | 6698.82 | M533F 9
5010140 | Dak | 0 | 1833 | 6975.4 | M533F 9
5010150 | Dak | 0 | 909 | 6975.4 | M533F 9
5010891 | Dak | 0 | 93.106 | 6580.1 | M533F 9
5010909 | Dak | 0 | 73.8729 | 6616 | M533F 9
5011510 | Dak | 0 | 379.103 | 6782.15 | M533F 9
5011582 | Dak | 0 | 76 | 6722.82 | M533F 9
5011592 | Dak | 0 | 7.9979 | 6711.44 | M533F 9
5011740 | Dak | 0 | 37.1699 | 6750.35 | M533F 9
5011748 | Dak | 0 | 2152.98 | 6776.33 | M533F 9
5011858 | Dak | 0 | 385.922 | 6816.66 | M533F 9
5011932 | Dak | 0 | 61 | 6767.94 | M533F 9
5011942 | Dak | 0 | 22.9826 | 6756.56 | M533F 9
5012005 | Dak | 0 | 30.7893 | 6789.36 | M533F 9
5012039 | Dak | 0 | 527.298 | 6737.32 | M533F 9
5012148 | Dak | 0 | 378.228 | 6972.85 | M533F 9
5012166 | Dak | 0 | 66 | 6920.6 | M533F 9
5012176 | Dak | 0 | 23 | 6909.21 | M533F 9
5012273 | Dak | 0 | 39.566 | 6939.35 | M533F 9
5012281 | Dak | 0 | 690.153 | 6926.3 | M533F 9
5012581 | Dak | 0 | 3055.68 | 6580.1 | M533F 9
5012591 | Dak | 0 | 1248.39 | 6580.1 | M533F 9; M5337F 1
5013090 | V00 | 0 | 2953 | 2401 | M5421 2
5013115 | V00 | 0 | 2953 | 2401 | M5332F 2
5013140 | V00 | 0 | 2953 | 2401 | M5332R 5
5013163 | V00 | 0 | 2952.25 | 2401 | M533F 3
5013532 | V01 | 0 | 547.052 | 5369.35 | M533F 3
5013853 | Dak | 0 | 573.236 | 5369.35 | M533F 3
5014222 | V01 | 0 | 86.4683 | 5369.35 | M533F 3
5014432 | V01 | 0 | 522.252 | 5370.1 | M5332R 5
5014860 | Dak | 0 | 68.5705 | 5370.1 | M5332R 5
5014945 | Dak | 0 | 5491.63 | 5370.1 | M5332R 5
5015099 | V01 | 0 | 528.956 | 5370.1 | M5332F 2
5015449 | Dak | 0 | 67.4406 | 5370.1 | M5332F 2
5015488 | Dak | 0 | 4955.16 | 5370.1 | M5332F 2
5015565 | Dak | 0 | 122.009 | 5370.1 | M5332F 2
5015678 | Dak | 0 | 405.43 | 5370.1 | M5332F 2
5016359 | Dak | 0 | 5262.4 | 5370.1 | M5421 2
5016672 | Dak | 0 | 133.361 | 5370.1 | M5421 2
5017136 | V00 | 0 | 5776.33 | 2365.1 | M5421 1
5017245 | V00 | 0 | 25.4975 | 2376.48 | M5421 1
5017284 | V00 | 0 | 14 | 2365.1 | M5421 1
5017299 | V00 | 0 | 25.4975 | 2376.48 | M5421 1
5017305 | V00 | 0 | 2631.09 | 2365.1 | M5421 1
5017366 | V00 | 0 | 5639 | 2365.1 | M5332F 1
5017438 | V00 | 0 | 3176.38 | 2365.1 | M533F 1
5017528 | V00 | 0 | 392.622 | 2400.1 | M533F 1
5017539 | V00 | 0 | 25.4975 | 2376.48 | M533F 1
5017546 | V00 | 0 | 27 | 2365.1 | M533F 1
5017643 | V00 | 0 | 25.4975 | 2376.48 | M533F 1
5017650 | V00 | 0 | 2161.34 | 2365.1 | M533F 1
5017918 | V00 | 0 | 4052.19 | 2365.1 | M5337F 1
5018049 | V00 | 0 | 6347.35 | 2365.1 | M5337F 1
5018092 | V00 | 0 | 342 | 2365.1 | M5332R 6
5018105 | V00 | 0 | 121 | 2400.1 | M5332R 6
5018236 | V00 | 0 | 25.4975 | 2376.48 | M5332R 6
5018242 | V00 | 0 | 1376.09 | 2353.1 | M5332R 6
5018361 | V00 | 0 | 42.468 | 2364.48 | M5332R 6
5018570 | V00 | 0 | 41.1892 | 2400.1 | M533F 1
5018579 | V00 | 0 | 25.4975 | 2376.48 | M533F 1
5018651 | V00 | 0 | 42.1186 | 2365.1 | M5332R 4
5018668 | V00 | 0 | 101 | 2400.1 | M5332R 4
5018689 | V00 | 0 | 25.4975 | 2376.48 | M5332R 4
5018997 | V00 | 0 | 25.4975 | 2376.48 | M5332R 4
5019017 | V00 | 0 | 1795.35 | 2365.1 | M5332R 4
5019130 | V00 | 0 | 1500.93 | 2365.1 | M5421 1
5019223 | V00 | 0 | 25.4975 | 2376.48 | M5421 1
5019403 | V00 | 0 | 634.898 | 2400.1 | M5421 1
5019438 | V00 | 0 | 25.4975 | 2376.48 | M5332F 2
5019565 | V00 | 0 | 470.441 | 2400.1 | M5332F 2
5019586 | V00 | 0 | 52.0003 | 2400.1 | M5332F 2
5019748 | V00 | 0 | 757.986 | 2400.1 | M5421 1
5019811 | V00 | 0 | 25.4975 | 2376.48 | M5332F 2
5019836 | V00 | 0 | 163 | 2365.1 | M5332F 2
5019941 | V00 | 0 | 1686.65 | 2400.1 | M5332F 2
5020057 | V00 | 0 | 126.315 | 2400.1 | M5332F 2
5020090 | V00 | 0 | 33.7997 | 2364 | M5332F 2
5020091 | V00 | 0 | 19.8975 | 2380.44 | M5332F 2
5020159 | V00 | 0 | 3313.28 | 2365.1 | M5332R 1
5020219 | V00 | 0 | 6057.47 | 2365.1 | M5332R 1
5020245 | V00 | 0 | 112.593 | 2365.1 | M5332R 1
5020364 | Dak | 0 | 30.0802 | 5370.1 | M5421 2
5020382 | Dak | 0 | 743.812 | 5370.1 | M5421 2
5020736 | V00 | 0 | 2948 | 2401 | M5332R 4
5020760 | Dak | 0 | 969.367 | 5365.1 | M5332R 4
5020772 | Dak | 0 | 2599.05 | 5365.1 | M5332R 4
5020935 | Dak | 0 | 962.657 | 5370.1 | M5332R 5
5020943 | Dak | 0 | 144.931 | 5174.11 | M5332R 5
5020985 | Dak | 0 | 1100.66 | 5390.1 | M5332R 3
5020993 | Dak | 0 | 156.745 | 5174.11 | M5332R 3
5021028 | Dak | 0 | 966.873 | 5370.1 | M5421 2
5021036 | Dak | 0 | 151.08 | 5174.11 | M5421 2
5021069 | Dak | 0 | 6356.17 | 5365.1 | M5332R 4
5021383 | Dak | 0 | 329.939 | 5401 | M5332R 4
5021620 | Dak | 0 | 1948.44 | 5739.89 | M5332R 4
5022093 | Dak | 0 | 50.9307 | 5370.1 | M5332R 5
5022097 | Dak | 0 | 143.986 | 5210.01 | M5332R 5
5022116 | Dak | 0 | 305.745 | 5390.1 | M5332R 3
5022132 | Dak | 0 | 163.986 | 5210.01 | M5332R 3
5022146 | Dak | 0 | 552.915 | 5370.1 | M5421 2
5022162 | Dak | 0 | 143.986 | 5210.01 | M5421 2
5022553 | Dak | 0 | 1679.68 | 5408.47 | M533F 10
5022982 | Dak | 0 | 2555.25 | 5410.04 | M533F 10
5023096 | Dak | 0 | 842.855 | 5634.98 | M533F 10
5023106 | Dak | 0 | 9.2036 | 5767.7 | M533F 8
5023167 | Dak | 0 | 1959.93 | 5637.12 | M533F 10
5023251 | Dak | 0 | 1466.43 | 5634.98 | M533F 10
5024639 | Dak | 0 | 43.1543 | 5373 | M5332R 8
5024697 | Dak | 0 | 1565.66 | 5409.1 | M5332R 8
5024740 | Dak | 0 | 2348.62 | 5410.67 | M5332R 8
5024823 | Dak | 0 | 991.039 | 5614.57 | M5332R 7
5024960 | Dak | 0 | 720 | 5559.76 | M5332R 7
5025822 | Dak | 0 | 1330.78 | 5617.6 | M5332R 8
5025886 | Dak | 0 | 2120.26 | 5615.8 | M5332R 7
5026103 | Dak | 0 | 5453.41 | 5369.35 | M533F 3
5026155 | Dak | 0 | 43.3205 | 5372.25 | M533F 10
5026235 | Dak | 0 | 1388.07 | 5409.1 | M5332F 5
5026252 | Dak | 0 | 43.1543 | 5373 | M5332F 5
5026277 | Dak | 0 | 2226.76 | 5410.6 | M5332F 5
5026317 | Dak | 0 | 907.638 | 5606.9 | M5332F 5
5027023 | Dak | 0 | 22.1091 | 5618.28 | M5332F 5
5027040 | Dak | 0 | 58.5 | 5639.5 | M5332F 5
5027048 | Dak | 0 | 15.4688 | 5622.98 | M5332F 5
5027058 | Dak | 0 | 63.3995 | 5611.6 | M5332F 5
5027141 | Dak | 0 | 2290.95 | 5612.61 | M5332F 5
5027351 | Dak | 0 | 540.991 | 5576.99 | M5332F 5
5027671 | Dak | 0 | 1180.76 | 5606.9 | M5332F 5
5029884 | Dak | 0 | 3439.31 | 5594.47 | M531 2
5030232 | Dak | 0 | 288 | 5896.46 | M531 2
5030240 | Dak | 0 | 1585.7 | 5896.5 | M531 2
5030296 | Dak | 0 | 658 | 5896.5 | M531 2
5030333 | Dak | 0 | 594 | 5896.5 | M531 2
5030364 | Dak | 0 | 1021.7 | 5896.5 | M531 2
5030383 | Dak | 0 | 1061.89 | 5896.5 | M531 2
5030410 | Dak | 0 | 362.687 | 5552.4 | M531 2
5030527 | Dak | 0 | 137 | 5990.1 | M531 1
5030713 | Dak | 0 | 3573 | 2401 | M531 1
5030807 | V01 | 0 | 249 | 2365.1 | M531 1
5030965 | V01 | 0 | 1968.24 | 2365.1 | M531 3
5030973 | V01 | 0 | 71.2304 | 2365.1 | M531 3
5030986 | V01 | 0 | 362 | 2365.1 | M531 3
5031163 | V01 | 0 | 668 | 2365.1 | M531 3
5031184 | V01 | 0 | 444 | 2365.1 | M531 3
5031223 | V01 | 0 | 1594 | 2365.1 | M531 3
5031235 | V01 | 0 | 1534 | 2365.1 | M531 3
5031338 | V01 | 0 | 1911.23 | 2365.1 | M531 3
5031344 | V01 | 0 | 4318 | 2365.1 | M531 3
5031868 | V01 | 0 | 423 | 2401 | M531 3
5031886 | V00 | 0 | 5496.4 | 2840.1 | M531 3
5031967 | V01 | 0 | 1716.4 | 2840.1 | M531 3
5032000 | V01 | 0 | 8214 | 2840.1 | M531 3

# IfcFlowSegment: Rectangular Duct:LUKA_Verzinkt 3m (31)
Pset_DistributionFlowElementCommon - Reference: LUKA_Verzinkt 3m; sets with these values: 2
Pset_ElementShading - Roughness: 0.15 mm
Pset_FlowSegmentDuctSegment - sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Ducts
Name (Rectangular Duct:LUKA_Verzinkt 3m:...) | In | Length (mm) | Group | Pset_ElementShading, Color = Pset_FlowSegmentDuctSegment, Color
4458516 | V00 | 120.197 | M570R 4
4458520 | V00 | 5354.53 | M570R 4
4484462 | Dak | 380 | M570R 6
4484476 | Dak | 403.466 | M570R 10
4484525 | Dak | 1220.31 | M570F 3
4484696 | Dak | 2203.16 | M570F 3
4485598 | Dak | 956.129 | M570R 10
4485602 | Dak | 5148.81 | M570R 10
4496999 | Dak | 141.259 | M570F 16
4497263 | Dak | 3886.1 | M570F 16
4508467 | Dak | 393.754 | M570R 12
4513108 | Dak | 772.071 | M570R 12
4513122 | Dak | 1177.19 | M570F 3
4513125 | Dak | 2433.45 | M570F 3
4513128 | Dak | 1233.13 | M570F 3
4542902 | Dak | 3806.1 | M570R 8 | 0
4551753 | Dak | 2158.5 | M570F 3 | 0
4551864 | Dak | 1733.23 | M570F 3 | 0
4552960 | Dak | 1520 | M570F 3 | 0
4552967 | Dak | 1213.79 | M570F 3 | 0
4553105 | Dak | 766.206 | M570F 16 | 0
4553337 | V00 | 327.883 | M570R 4 | 0
4553344 | V00 | 1120.6 | M570R 4 | 0
4554263 | Dak | 2175.63 | M570R 12 | 0
4555056 | Dak | 30 | M570R 12 | 0
4555074 | Dak | 230 | M570R 12 | 0
4556474 | Dak | 338.488 | M570R 10 | 0
4557084 | Dak | 20 | M570R 7 | 0
5033534 | V00 | 1250 | M570F 8 | 0
5034201 | V99 | 5400 | M570R 16 | 0
5034491 | V99 | 8500 | M570F 12 | 0

# IfcFlowSegment: Rectangular Duct:LUKA_Verzinkt 6m (7)
Pset_DistributionFlowElementCommon - Reference: LUKA_Verzinkt 6m; sets with these values: 2
Pset_ElementShading - Roughness: 0.15 mm
Pset_FlowSegmentDuctSegment - sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Ducts
Name (Rectangular Duct:LUKA_Verzinkt 6m:...) | In | Length (mm) | Group | Pset_ElementShading, Color = Pset_FlowSegmentDuctSegment, Color
4459245 | V00 | 4469.22 | M570F 3
4497270 | Dak | 3620.46 | M570R 4
4537757 | V00 | 1680 | M570R 4 | 0
4538100 | V00 | 575.164 | M570R 4 | 0
4538925 | V00 | 210 | M570R 4 | 0
4539247 | Dak | 5836.42 | M570R 4 | 0
4540285 | V00 | 840 | M570F 3 | 0

# IfcFlowSegment: Round Duct:Instort Kanalen_Spiro 3m, Round Duct:Instort Kanalen_Spiro 3m:4536908
In: Dak
Pset_DistributionFlowElementCommon - Reference: Instort Kanalen_Spiro 3m; sets with these values: 2
Pset_ElementShading - Roughness: 0.15 mm
Pset_FlowSegmentDuctSegment - Length: 35 mm; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Ducts
Group: M570F 33

# IfcFlowSegment: Round Duct:Instort Kanalen_Spiro 6m, Round Duct:Instort Kanalen_Spiro 6m:4536872
In: Dak
Pset_DistributionFlowElementCommon - Reference: Instort Kanalen_Spiro 6m; sets with these values: 2
Pset_ElementShading - Roughness: 0.15 mm
Pset_FlowSegmentDuctSegment - Length: 35 mm; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Ducts
Group: M570F 32

# IfcFlowSegment: Round Duct:LUKA_Verzinkt 3m (91)
Pset_DistributionFlowElementCommon - Reference: LUKA_Verzinkt 3m; sets with these values: 2
Pset_ElementShading - Roughness: 0.15 mm
Pset_FlowSegmentDuctSegment - sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Ducts
Name (Round Duct:LUKA_Verzinkt 3m:...) | In | Length (mm) | Group
4354656 | V00 | 469.408 | M570R 1
4361893 | V00 | 234.927 | M570R 2
4361909 | V00 | 3086.86 | M570F 2
4449504 | V00 | 191.7 | M570R 1
4449512 | V00 | 93.4388 | M570R 1
4452621 | V00 | 1531.72 | M570R 2
4452627 | V00 | 981.294 | M570R 2
4452631 | V00 | 4160.13 | M570R 1
4452637 | V00 | 1129.34 | M570R 2
4452643 | V00 | 935.147 | M570R 2
4452903 | V00 | 103.907 | M570F 2
4453157 | V00 | 5012.11 | M570F 2
4455764 | V00 | 2773.65 | M570F 2
4455770 | V00 | 1426.6 | M570F 2
4457988 | V00 | 1572.49 | M570F 6
4458458 | V01 | 1394.14 | M570R 3
4458929 | V01 | 1440.8 | M570R 5
4459183 | V00 | 2029.29 | M570F 1
4459191 | V01 | 67.7875 | M570F 9
4459199 | V01 | 59.542 | M570F 9
4459203 | V01 | 67.7875 | M570F 11
4459211 | V01 | 59.542 | M570F 7
4459218 | V01 | 67.7875 | M570F 13
4459226 | V01 | 59.542 | M570F 13
4459230 | V01 | 67.7875 | M570F 15
4459238 | V01 | 59.542 | M570F 15
4461073 | V01 | 6653.91 | M570F 1
4484468 | Dak | 1588.19 | M570R 1
4484481 | Dak | 3001 | M570R 9
4484485 | Dak | 619.866 | M570R 1
4484493 | Dak | 11.1144 | M570R 1
4484497 | Dak | 1206.11 | M570R 1
4484509 | Dak | 1464.31 | M570F 3
4484517 | Dak | 235.739 | M570F 3
4484572 | Dak | 4583.12 | M570R 1
4484576 | Dak | 759.89 | M570R 1
4484605 | Dak | 868.029 | M570R 1
4484624 | Dak | 2005.13 | M570F 3
4484685 | Dak | 288.906 | M570F 3
4484691 | Dak | 293.179 | M570F 3
4488903 | V02 | 300 | M570F 10
4496936 | Dak | 926.098 | M570R 15
4496945 | Dak | 67.7875 | M570F 18
4496953 | Dak | 59.542 | M570F 18
4496959 | Dak | 67.7875 | M570F 20
4496967 | Dak | 59.542 | M570F 20
4496973 | Dak | 67.7875 | M570F 23
4496981 | Dak | 59.542 | M570F 23
4496987 | Dak | 67.7875 | M570F 25
4496995 | Dak | 59.542 | M570F 25
4497872 | Dak | 160 | M570F 19
4497935 | Dak | 260 | M570F 21
4498008 | Dak | 10 | M570F 24
4498038 | Dak | 10 | M570F 26
4502820 | Dak | 442.6 | M570R 15
4502902 | Dak | 1055.57 | M570F 14
4537275 | V00 | 709.121 | M570F 5
4537287 | V00 | 360 | M570F 5
4537680 | V01 | 315.035 | M570R 3 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4537700 | Dak | 75 | M570R 3 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4539354 | V01 | 60 | Mechanical S4Rx_Supply Air 2 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4539658 | V01 | 59.542 | M570F 11; Mechanical S4Rx_Supply Air 1 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4540459 | V01 | 87.669 | M570F 1 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4540505 | V01 | 460 | M570F 1 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4540779 | V01 | 1651 | M570R 5 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4545187 | Dak | 158.065 | M570R 1 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4545204 | V00 | 626.5 | M570R 1 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4545262 | V00 | 1926.5 | M570R 1 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4550439 | Dak | 948.55 | M570F 3 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4555580 | V01 | 1600 | M570R 3 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4555853 | Dak | 920 | M570R 1 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4558401 | V00 | 115.48 | M570F 2 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4558517 | V00 | 131.533 | M570F 2 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4558545 | V00 | 137.853 | M570F 2 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4558809 | V00 | 154.046 | M570F 2 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4558932 | V00 | 269.033 | M570F 2 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4559071 | V00 | 55.2476 | M570F 2 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4559404 | V00 | 1825 | M570R 1 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4559419 | V00 | 75.0616 | M570R 1 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4559731 | Dak | 2131.33 | M570F 3 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4560370 | Dak | 660 | M570R 14 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4560649 | Dak | 367.71 | M570R 11 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4561792 | Dak | 222.707 | M570R 11 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4561891 | Dak | 102.2 | M570R 11 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4562249 | Dak | 756.662 | M570F 3 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4562286 | Dak | 398.666 | M570F 3 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4562292 | Dak | 149.082 | M570F 3 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4915608 | V00 | 146.116 | M570F 4 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4915644 | V00 | 357.912 | M570F 4 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4916023 | V01 | 578.688 | M570F 4 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0
4916112 | V00 | 72.2 | M570F 4 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0

# IfcFlowTerminal: Fan Coil Unit 2_Recht-recht, VE_Fan Coil Unit_1 Rect In 1 Rect Out 2 HC_MEPcontent_LUKA_FCU Rect-rect 2HC:Fan Coil Unit 2_Recht-recht:4457985
In: V00
Pset_DistributionFlowElementCommon - Reference: Fan Coil Unit 2_Recht-recht; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Mechanical Equipment
Group: M570F 5; M570F 6

# IfcFlowTerminal: N/A, 315 (10)
Type - Material: Color RGB 078-078-078
Pset_DistributionFlowElementCommon - Reference: N/A, 315; sets with these values: 2
Pset_ProductRequirements - Category: DM_ARTICLE_AIRTERMINAL
Name (VE_Air Terminal_Air Sock_MEPcontent_IN:N/A, 315:...) | In | Group
4459215 | V01 | Mechanical S4Rx_Supply Air 1
4459242 | V01
4459248 | V01
4459250 | V01
4484637 | Dak | M570F 10
4484639 | Dak | M570F 3
4496957 | Dak | M570F 26
4496971 | Dak | M570F 24
4496985 | Dak | M570F 21
4497261 | Dak | M570F 19

# IfcFlowTerminal: VE_Air Terminal_Grille on Duct_MEPcontent_IN (8)
Type - PredefinedType: GRILLE
Pset_DistributionFlowElementCommon - Reference: VE_Air Terminal_Grille on Duct_MEPcontent_IN; sets with these values: 2
Pset_ProductRequirements - Category: Air Terminals
Name (VE_Air Terminal_Grille on Duct_MEPcontent_IN:VE_Air Terminal_Grille on Duct_MEPcontent_IN:...) | In | Group
4452651 | V00 | M570F 2
4452907 | V00 | M570F 2
4453155 | V00 | M570F 2
4457986 | V00 | M570F 6
4457992 | V00 | M570F 6
4458933 | V01 | M570F 1
4459181 | V01 | M570F 1
4484534 | Dak | M570F 3

# IfcFlowTerminal: VE_Air Terminal_Grille on Duct_MEPcontent_OUT (12)
Type - PredefinedType: GRILLE
Pset_DistributionFlowElementCommon - Reference: VE_Air Terminal_Grille on Duct_MEPcontent_OUT; sets with these values: 2
Pset_ProductRequirements - Category: Air Terminals
Name (VE_Air Terminal_Grille on Duct_MEPcontent_OUT:VE_Air Terminal_Grille on Duct_MEPcontent_OUT:...) | In | Group
4449521 | V00 | M570R 1
4449769 | V00 | M570R 1
4458523 | V00 | M570R 4
4458525 | V00 | M570R 4
4458527 | V00 | M570R 4
4458529 | V00 | M570R 4
4458679 | V01 | M570R 5
4458927 | V01 | M570R 5
4484536 | Dak | M570R 1
4497003 | Dak | M570R 4
4497005 | Dak | M570R 4
4497007 | Dak | M570R 4

# IfcFlowTerminal: VE_Air Terminal_Wall Terminal Rectangular Connector_MEPcontent_OUT, VE_Air Terminal_Wall Terminal Rectangular Connector_MEPcontent_OUT:VE_Air Terminal_Wall Terminal Rectangular Connector_MEPcontent_OUT:4484466
In: Dak
Type - PredefinedType: GRILLE
Pset_DistributionFlowElementCommon - Reference: VE_Air Terminal_Wall Terminal Rectangular Connector_MEPcontent_OUT; sets with these values: 2
Pset_ProductRequirements - Category: Air Terminals
