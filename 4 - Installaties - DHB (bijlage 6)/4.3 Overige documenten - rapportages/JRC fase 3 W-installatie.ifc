Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcDistributionPort (2559)
Name | FlowDirection | Group
Port_5004403 | SOURCEANDSINK | M5421 1
InPort_5004403 | SOURCEANDSINK | M5421 1
2 x OutPort_5012692 | SOURCEANDSINK | M5421 1
InPort_5004425 | SOURCEANDSINK | M5332R 4
2 x OutPort_5012673 | SOURCEANDSINK | M5332R 4
2 x InPort_5004482 | SOURCEANDSINK | M5332R 4
OutPort_5004488 | SOURCEANDSINK | M5332R 4
InPort_5004488 | SOURCEANDSINK | M5332R 4
2 x OutPort_5005531 | SOURCEANDSINK | M5332R 4
2 x InPort_5012779 | SINK | M5337F 1
OutPort_5004745 | SOURCE | M5337F 1
InPort_5004745 | SINK | M5337F 1
OutPort_5004753 | SOURCE | M5337F 1
InPort_5004891 | SOURCEANDSINK | M5421 1
2 x OutPort_5004909 | SOURCEANDSINK | M5421 1
2 x InPort_5004903 | SOURCEANDSINK | M5421 1
InPort_5004948 | SOURCEANDSINK | M533F 7
2 x OutPort_5007576 | SOURCEANDSINK | M533F 7
2 x InPort_5004956 | SOURCEANDSINK | M533F 7
OutPort_5004962 | SOURCEANDSINK | M533F 7
InPort_5004962 | SOURCEANDSINK | M533F 7
2 x OutPort_5007578 | SOURCEANDSINK | M533F 7
2 x InPort_5005448 | SOURCEANDSINK | M5332R 4
2 x OutPort_5005816 | SOURCEANDSINK | M5332R 4
2 x OutPort_5006452 | SOURCEANDSINK | M5332R 4
2 x InPort_5005524 | SOURCEANDSINK | M5332R 4
OutPort_5005529 | SOURCEANDSINK | M5332R 4
2 x InPort_5005529 | SOURCEANDSINK | M5332R 4
2 x InPort_5005820 | SOURCEANDSINK | M5332R 4
OutPort_5007204 | SOURCEANDSINK | M5332R 4
InPort_5006298 | SOURCEANDSINK | M5332R 4
InPort_5006358 | SOURCEANDSINK | M5421 1
InPort_5006452 | SOURCEANDSINK | M5332R 4
OutPort_5006699 | SOURCEANDSINK | M5332R 4
InPort_5006699 | SOURCEANDSINK | M5332R 4
2 x OutPort_5006794 | SOURCEANDSINK | M5332R 4
2 x InPort_5006763 | SOURCEANDSINK | M5332R 4
OutPort_5007205 | SOURCEANDSINK | M5332R 4
InPort_5006794 | SOURCEANDSINK | M5332R 4
OutPort_5006809 | SOURCEANDSINK | M5332R 4
InPort_5006809 | SOURCEANDSINK | M5332R 4
2 x OutPort_5007072 | SOURCEANDSINK | M5332R 4
2 x InPort_5007064 | SOURCEANDSINK | M5332R 4
OutPort_5007206 | SOURCEANDSINK | M5332R 4
Port_5007204 | SOURCEANDSINK | M5332R 4
Port_5007205 | SOURCEANDSINK | M5332R 4
Port_5007206 | SOURCEANDSINK | M5332R 4
2 x InPort_5007331 | SOURCEANDSINK | M533F 7
2 x OutPort_5007574 | SOURCEANDSINK | M533F 7
2 x OutPort_5007812 | SOURCEANDSINK | M533F 7
2 x InPort_5007570 | SOURCEANDSINK | M533F 7
InPort_5007576 | SOURCEANDSINK | M533F 7
2 x InPort_5007804 | SOURCEANDSINK | M533F 7
2 x OutPort_5008074 | SOURCEANDSINK | M533F 7
2 x InPort_5007987 | SOURCEANDSINK | M533F 7
OutPort_5008063 | SOURCEANDSINK | M533F 7
Port_5008063 | SOURCEANDSINK | M533F 7
2 x InPort_5008124 | SOURCEANDSINK | M5332R 2
2 x OutPort_5008493 | SOURCEANDSINK | M5332R 2
2 x OutPort_5008644 | SOURCEANDSINK | M5332R 2
2 x InPort_5008489 | SOURCEANDSINK | M5332R 2
OutPort_5008495 | SOURCEANDSINK | M5332R 2
InPort_5008495 | SOURCEANDSINK | M5332R 2
OutPort_5008871 | SOURCEANDSINK | M5332R 2
2 x InPort_5008632 | SOURCEANDSINK | M5332R 2
2 x OutPort_5008829 | SOURCEANDSINK | M5332R 2
InPort_5008736 | SOURCEANDSINK | M5332R 2
OutPort_5008821 | SOURCEANDSINK | M5332R 2
Port_5008736 | SOURCEANDSINK | M5332R 2
InPort_5008821 | SOURCEANDSINK | M5332R 2
InPort_5008871 | SOURCEANDSINK | M5332R 2
2 x OutPort_5008885 | SOURCEANDSINK | M5332R 2
2 x InPort_5008879 | SOURCEANDSINK | M5332R 2
2 x InPort_5009146 | SOURCEANDSINK | M5332F 3
2 x OutPort_5009389 | SOURCEANDSINK | M5332F 3
2 x OutPort_5009781 | SOURCEANDSINK | M5332F 3
2 x InPort_5009381 | SOURCEANDSINK | M5332F 3
2 x OutPort_5009766 | SOURCEANDSINK | M5332F 3
2 x Port_5009655 | SOURCEANDSINK | M5332F 4
InPort_5009754 | SOURCEANDSINK | M5332F 3
Port_5009754 | SOURCEANDSINK | M5332F 3
2 x InPort_5009777 | SOURCEANDSINK | M5332F 3
OutPort_5009783 | SOURCEANDSINK | M5332F 3
InPort_5009783 | SOURCEANDSINK | M5332F 3
OutPort_5009796 | SOURCEANDSINK | M5332F 3
InPort_5009796 | SOURCEANDSINK | M5332F 3
2 x OutPort_5009812 | SOURCEANDSINK | M5332F 3
2 x InPort_5009806 | SOURCEANDSINK | M5332F 3
InPort_5010911 | SINK | M533F 9
OutPort_5009896 | SOURCE | M533F 9
InPort_5009896 | SINK | M533F 9
OutPort_5011746 | SOURCE | M533F 9
2 x InPort_5010140 | SOURCEANDSINK | M533F 9
2 x OutPort_5010456 | SOURCEANDSINK | M533F 9
OutPort_5012263 | SOURCEANDSINK | M533F 9
2 x InPort_5010150 | SOURCEANDSINK | M533F 9
OutPort_5010381 | SOURCEANDSINK | M533F 9
Port_5010381 | SOURCEANDSINK | M533F 9
InPort_5010915 | SINK | M533F 9
OutPort_5010891 | SOURCE | M533F 9
InPort_5010891 | SINK | M533F 9
OutPort_5010913 | SOURCE | M533F 9
InPort_5010909 | SINK | M533F 9
OutPort_5010911 | SOURCE | M533F 9
InPort_5010913 | SINK | M533F 9
OutPort_5010909 | SOURCE | M533F 9
InPort_5012581 | SINK | M533F 9
OutPort_5010915 | SOURCE | M533F 9
2 x InPort_5011510 | SOURCEANDSINK | M533F 9
2 x OutPort_5011590 | SOURCEANDSINK | M533F 9
2 x OutPort_5011744 | SOURCEANDSINK | M533F 9
2 x InPort_5011582 | SOURCEANDSINK | M533F 9
2 x OutPort_5011600 | SOURCEANDSINK | M533F 9
2 x InPort_5011592 | SOURCEANDSINK | M533F 9
OutPort_5012369 | SOURCEANDSINK | M533F 9
2 x InPort_5011740 | SOURCEANDSINK | M533F 9
OutPort_5011746 | SOURCEANDSINK | M533F 9
InPort_5011746 | SOURCEANDSINK | M533F 9
2 x OutPort_5012039 | SOURCEANDSINK | M533F 9
2 x InPort_5011748 | SOURCEANDSINK | M533F 9
2 x OutPort_5012279 | SOURCEANDSINK | M533F 9
2 x OutPort_5012038 | SOURCEANDSINK | M533F 9
2 x InPort_5011858 | SOURCEANDSINK | M533F 9
2 x OutPort_5012009 | SOURCEANDSINK | M533F 9
2 x OutPort_5011940 | SOURCEANDSINK | M533F 9
2 x InPort_5011932 | SOURCEANDSINK | M533F 9
2 x OutPort_5011948 | SOURCEANDSINK | M533F 9
2 x InPort_5011942 | SOURCEANDSINK | M533F 9
OutPort_5012366 | SOURCEANDSINK | M533F 9
2 x InPort_5012005 | SOURCEANDSINK | M533F 9
InPort_5012038 | SOURCEANDSINK | M533F 9
2 x InPort_5012148 | SOURCEANDSINK | M533F 9
2 x OutPort_5012277 | SOURCEANDSINK | M533F 9
2 x OutPort_5012174 | SOURCEANDSINK | M533F 9
2 x InPort_5012166 | SOURCEANDSINK | M533F 9
2 x OutPort_5012182 | SOURCEANDSINK | M533F 9
2 x InPort_5012176 | SOURCEANDSINK | M533F 9
OutPort_5012363 | SOURCEANDSINK | M533F 9
InPort_5012263 | SOURCEANDSINK | M533F 9
2 x OutPort_5012281 | SOURCEANDSINK | M533F 9
2 x InPort_5012273 | SOURCEANDSINK | M533F 9
InPort_5012279 | SOURCEANDSINK | M533F 9
Port_5012363 | SOURCEANDSINK | M533F 9
Port_5012366 | SOURCEANDSINK | M533F 9
Port_5012369 | SOURCEANDSINK | M533F 9
InPort_5012597 | SINK | M533F 9
OutPort_5012581 | SOURCE | M533F 9
InPort_5012591 | SINK | M533F 9
OutPort_5012597 | SOURCE | M533F 9
OutPort_5012591 | SOURCE | M5337F 1
2 x InPort_5013090 | SOURCEANDSINK | M5421 2
OutPort_5016039 | SOURCEANDSINK | M5421 2
2 x InPort_5013115 | SOURCEANDSINK | M5332F 2
2 x OutPort_5015138 | SOURCEANDSINK | M5332F 2
2 x InPort_5013140 | SOURCEANDSINK | M5332R 5
OutPort_5014262 | SOURCEANDSINK | M5332R 5
2 x InPort_5013163 | SOURCEANDSINK | M533F 3
2 x OutPort_5013542 | SOURCEANDSINK | M533F 3
2 x InPort_5013532 | SOURCEANDSINK | M533F 3
2 x OutPort_5014228 | SOURCEANDSINK | M533F 3
2 x InPort_5013686 | SOURCEANDSINK | M533F 3
OutPort_5013853 | SOURCEANDSINK | M533F 3
2 x OutPort_5026103 | SOURCEANDSINK | M533F 3
InPort_5013853 | SOURCEANDSINK | M533F 3
OutPort_5014041 | SOURCEANDSINK | M533F 3
Port_5014041 | SOURCEANDSINK | M533F 3
2 x InPort_5014222 | SOURCEANDSINK | M533F 3
OutPort_5014226 | SOURCEANDSINK | M533F 3
InPort_5014226 | SOURCEANDSINK | M533F 3
InPort_5014262 | SOURCEANDSINK | M5332R 5
OutPort_5014432 | SOURCEANDSINK | M5332R 5
InPort_5014432 | SOURCEANDSINK | M5332R 5
2 x OutPort_5014863 | SOURCEANDSINK | M5332R 5
2 x InPort_5014860 | SOURCEANDSINK | M5332R 5
2 x OutPort_5014984 | SOURCEANDSINK | M5332R 5
2 x InPort_5014945 | SOURCEANDSINK | M5332R 5
OutPort_5014970 | SOURCEANDSINK | M5332R 5
InPort_5014970 | SOURCEANDSINK | M5332R 5
OutPort_5020935 | SOURCEANDSINK | M5332R 5
2 x InPort_5015099 | SOURCEANDSINK | M5332F 2
2 x OutPort_5015453 | SOURCEANDSINK | M5332F 2
InPort_5015124 | SOURCEANDSINK | M5332R 3
OutPort_5020985 | SOURCEANDSINK | M5332R 3
Port_5015124 | SOURCEANDSINK | M5332R 3
2 x InPort_5015449 | SOURCEANDSINK | M5332F 2
OutPort_5015455 | SOURCEANDSINK | M5332F 2
InPort_5015455 | SOURCEANDSINK | M5332F 2
OutPort_5015488 | SOURCEANDSINK | M5332F 2
InPort_5015488 | SOURCEANDSINK | M5332F 2
2 x OutPort_5015569 | SOURCEANDSINK | M5332F 2
2 x InPort_5015565 | SOURCEANDSINK | M5332F 2
OutPort_5015571 | SOURCEANDSINK | M5332F 2
InPort_5015571 | SOURCEANDSINK | M5332F 2
OutPort_5015678 | SOURCEANDSINK | M5332F 2
Port_5015678 | SOURCEANDSINK | M5332F 2
InPort_5016039 | SOURCEANDSINK | M5421 2
OutPort_5020382 | SOURCEANDSINK | M5421 2
2 x InPort_5016351 | SOURCEANDSINK | M5421 2
OutPort_5016359 | SOURCEANDSINK | M5421 2
OutPort_5016672 | SOURCEANDSINK | M5421 2
InPort_5016359 | SOURCEANDSINK | M5421 2
2 x OutPort_5020379 | SOURCEANDSINK | M5421 2
InPort_5016672 | SOURCEANDSINK | M5421 2
OutPort_5016712 | SOURCEANDSINK | M5421 2
InPort_5016712 | SOURCEANDSINK | M5421 2
OutPort_5021028 | SOURCEANDSINK | M5421 2
InPort_5017136 | SOURCEANDSINK | M5421 1
2 x OutPort_5017247 | SOURCEANDSINK | M5421 1
2 x InPort_5017245 | SOURCEANDSINK | M5421 1
OutPort_5017249 | SOURCEANDSINK | M5421 1
Port_5017249 | SOURCEANDSINK | M5421 1
2 x InPort_5017284 | SOURCEANDSINK | M5421 1
2 x OutPort_5017313 | SOURCEANDSINK | M5421 1
2 x OutPort_5017303 | SOURCEANDSINK | M5421 1
2 x InPort_5017299 | SOURCEANDSINK | M5421 1
OutPort_5017301 | SOURCEANDSINK | M5421 1
InPort_5017301 | SOURCEANDSINK | M5421 1
2 x OutPort_5019403 | SOURCEANDSINK | M5421 1
InPort_5017305 | SOURCEANDSINK | M5421 1
Port_5017366 | SOURCEANDSINK | M5332F 1
InPort_5017438 | SOURCEANDSINK | M533F 1
2 x OutPort_5017541 | SOURCEANDSINK | M533F 1
2 x InPort_5017528 | SOURCEANDSINK | M533F 1
2 x OutPort_5017645 | SOURCEANDSINK | M533F 1
2 x OutPort_5017543 | SOURCEANDSINK | M533F 1
2 x InPort_5017539 | SOURCEANDSINK | M533F 1
2 x InPort_5017546 | SOURCEANDSINK | M533F 1
2 x OutPort_5017713 | SOURCEANDSINK | M533F 1
2 x OutPort_5017647 | SOURCEANDSINK | M533F 1
2 x InPort_5017643 | SOURCEANDSINK | M533F 1
InPort_5017650 | SOURCEANDSINK | M533F 1
InPort_5017918 | SOURCEANDSINK | M5337F 1
2 x OutPort_5018061 | SOURCEANDSINK | M5337F 1
Port_5018049 | SOURCEANDSINK | M5337F 1
InPort_5018049 | SOURCEANDSINK | M5337F 1
2 x InPort_5018092 | SOURCEANDSINK | M5332R 6
OutPort_5018098 | SOURCEANDSINK | M5332R 6
2 x OutPort_5018238 | SOURCEANDSINK | M5332R 6
Port_5018098 | SOURCEANDSINK | M5332R 6
2 x InPort_5018105 | SOURCEANDSINK | M5332R 6
2 x OutPort_5018363 | SOURCEANDSINK | M5332R 6
2 x OutPort_5018240 | SOURCEANDSINK | M5332R 6
2 x InPort_5018236 | SOURCEANDSINK | M5332R 6
InPort_5018242 | SOURCEANDSINK | M5332R 6
2 x OutPort_5018383 | SOURCEANDSINK | M5332R 6
2 x InPort_5018361 | SOURCEANDSINK | M5332R 6
OutPort_5018376 | SOURCEANDSINK | M5332R 6
InPort_5018376 | SOURCEANDSINK | M5332R 6
InPort_5018570 | SOURCEANDSINK | M533F 1
2 x OutPort_5018583 | SOURCEANDSINK | M533F 1
Port_5018570 | SOURCEANDSINK | M533F 1
2 x InPort_5018579 | SOURCEANDSINK | M533F 1
2 x InPort_5018651 | SOURCEANDSINK | M5332R 4
2 x OutPort_5018691 | SOURCEANDSINK | M5332R 4
2 x InPort_5018668 | SOURCEANDSINK | M5332R 4
2 x OutPort_5018999 | SOURCEANDSINK | M5332R 4
2 x OutPort_5018693 | SOURCEANDSINK | M5332R 4
2 x InPort_5018689 | SOURCEANDSINK | M5332R 4
2 x InPort_5018997 | SOURCEANDSINK | M5332R 4
OutPort_5019001 | SOURCEANDSINK | M5332R 4
InPort_5019001 | SOURCEANDSINK | M5332R 4
OutPort_5019017 | SOURCEANDSINK | M5332R 4
InPort_5019017 | SOURCEANDSINK | M5332R 4
2 x OutPort_5020746 | SOURCEANDSINK | M5332R 4
InPort_5019130 | SOURCEANDSINK | M5421 1
2 x OutPort_5019225 | SOURCEANDSINK | M5421 1
2 x InPort_5019223 | SOURCEANDSINK | M5421 1
OutPort_5019232 | SOURCEANDSINK | M5421 1
InPort_5019232 | SOURCEANDSINK | M5421 1
OutPort_5019748 | SOURCEANDSINK | M5421 1
Port_5019401 | SINK | M5421 1
InPort_5019748 | SINK | M5421 1
OutPort_5019401 | SOURCE | M5421 1
InPort_5019401 | SOURCEANDSINK | M5421 1
2 x InPort_5019438 | SOURCEANDSINK | M5332F 2
OutPort_5019442 | SOURCEANDSINK | M5332F 2
InPort_5019442 | SOURCEANDSINK | M5332F 2
OutPort_5019565 | SOURCEANDSINK | M5332F 2
InPort_5019565 | SOURCEANDSINK | M5332F 2
2 x OutPort_5019873 | SOURCEANDSINK | M5332F 2
2 x InPort_5019586 | SOURCEANDSINK | M5332F 2
2 x OutPort_5019813 | SOURCEANDSINK | M5332F 2
2 x InPort_5019811 | SOURCEANDSINK | M5332F 2
OutPort_5019820 | SOURCEANDSINK | M5332F 2
InPort_5019820 | SOURCEANDSINK | M5332F 2
OutPort_5019836 | SOURCEANDSINK | M5332F 2
Port_5019836 | SOURCEANDSINK | M5332F 2
InPort_5019873 | SOURCEANDSINK | M5332F 2
OutPort_5019941 | SOURCEANDSINK | M5332F 2
InPort_5019941 | SOURCEANDSINK | M5332F 2
2 x OutPort_5020110 | SOURCEANDSINK | M5332F 2
2 x InPort_5020057 | SOURCEANDSINK | M5332F 2
2 x OutPort_5020101 | SOURCEANDSINK | M5332F 2
InPort_5020090 | SOURCEANDSINK | M5332F 2
2 x OutPort_5020094 | SOURCEANDSINK | M5332F 2
2 x InPort_5020091 | SOURCEANDSINK | M5332F 2
InPort_5020159 | SOURCEANDSINK | M5332R 1
2 x OutPort_5020243 | SOURCEANDSINK | M5332R 1
InPort_5020219 | SOURCEANDSINK | M5332R 1
InPort_5020243 | SOURCEANDSINK | M5332R 1
OutPort_5020245 | SOURCEANDSINK | M5332R 1
Port_5020245 | SOURCEANDSINK | M5332R 1
2 x InPort_5020364 | SOURCEANDSINK | M5421 2
2 x OutPort_5020390 | SOURCEANDSINK | M5421 2
InPort_5020382 | SOURCEANDSINK | M5421 2
2 x InPort_5020736 | SOURCEANDSINK | M5332R 4
2 x OutPort_5020770 | SOURCEANDSINK | M5332R 4
2 x InPort_5020760 | SOURCEANDSINK | M5332R 4
2 x OutPort_5020844 | SOURCEANDSINK | M5332R 4
Port_5020772 | SOURCEANDSINK | M5332R 4
InPort_5020772 | SOURCEANDSINK | M5332R 4
InPort_5020844 | SOURCEANDSINK | M5332R 4
OutPort_5021069 | SOURCEANDSINK | M5332R 4
InPort_5020935 | SOURCEANDSINK | M5332R 5
OutPort_5022091 | SOURCEANDSINK | M5332R 5
2 x InPort_5020943 | SOURCEANDSINK | M5332R 5
OutPort_5021166 | SOURCEANDSINK | M5332R 5
2 x OutPort_5022101 | SOURCEANDSINK | M5332R 5
InPort_5020985 | SOURCEANDSINK | M5332R 3
2 x OutPort_5022124 | SOURCEANDSINK | M5332R 3
2 x InPort_5020993 | SOURCEANDSINK | M5332R 3
OutPort_5021169 | SOURCEANDSINK | M5332R 3
2 x OutPort_5022138 | SOURCEANDSINK | M5332R 3
InPort_5021028 | SOURCEANDSINK | M5421 2
2 x OutPort_5022154 | SOURCEANDSINK | M5421 2
2 x InPort_5021036 | SOURCEANDSINK | M5421 2
2 x OutPort_5022167 | SOURCEANDSINK | M5421 2
OutPort_5021170 | SOURCEANDSINK | M5421 2
InPort_5021069 | SOURCEANDSINK | M5332R 4
2 x OutPort_5021391 | SOURCEANDSINK | M5332R 4
Port_5021166 | SOURCEANDSINK | M5332R 5
Port_5021169 | SOURCEANDSINK | M5332R 3
Port_5021170 | SINK | M5421 2
2 x InPort_5021383 | SOURCEANDSINK | M5332R 4
2 x OutPort_5021806 | SOURCEANDSINK | M5332R 4
2 x InPort_5021620 | SOURCEANDSINK | M5332R 4
OutPort_5021773 | SOURCEANDSINK | M5332R 4
Port_5021773 | SOURCEANDSINK | M5332R 4
InPort_5022091 | SOURCEANDSINK | M5332R 5
OutPort_5022093 | SOURCEANDSINK | M5332R 5
InPort_5022093 | SOURCEANDSINK | M5332R 5
2 x OutPort_5022103 | SOURCEANDSINK | M5332R 5
2 x InPort_5022097 | SOURCEANDSINK | M5332R 5
2 x InPort_5022116 | SOURCEANDSINK | M5332R 3
2 x OutPort_5022136 | SOURCEANDSINK | M5332R 3
2 x InPort_5022132 | SOURCEANDSINK | M5332R 3
2 x InPort_5022146 | SOURCEANDSINK | M5421 2
2 x OutPort_5022165 | SOURCEANDSINK | M5421 2
2 x InPort_5022162 | SOURCEANDSINK | M5421 2
2 x InPort_5022553 | SOURCEANDSINK | M533F 10
2 x OutPort_5022996 | SOURCEANDSINK | M533F 10
2 x OutPort_5026159 | SOURCEANDSINK | M533F 10
2 x InPort_5022982 | SOURCEANDSINK | M533F 10
2 x OutPort_5023312 | SOURCEANDSINK | M533F 10
2 x InPort_5023096 | SOURCEANDSINK | M533F 10
2 x OutPort_5023337 | SOURCEANDSINK | M533F 10
2 x OutPort_5023292 | SOURCEANDSINK | M533F 10
2 x Port_5023106 | SOURCEANDSINK | M533F 8
2 x InPort_5023167 | SOURCEANDSINK | M533F 10
OutPort_5023192 | SOURCEANDSINK | M533F 10
Port_5023192 | SOURCEANDSINK | M533F 10
2 x InPort_5023251 | SOURCEANDSINK | M533F 10
InPort_5024639 | SOURCEANDSINK | M5332R 8
OutPort_5024643 | SOURCEANDSINK | M5332R 8
Port_5024639 | SOURCEANDSINK | M5332R 8
InPort_5024643 | SOURCEANDSINK | M5332R 8
OutPort_5024697 | SOURCEANDSINK | M5332R 8
InPort_5024697 | SOURCEANDSINK | M5332R 8
OutPort_5024721 | SOURCEANDSINK | M5332R 8
InPort_5024721 | SOURCEANDSINK | M5332R 8
OutPort_5024740 | SOURCEANDSINK | M5332R 8
InPort_5024740 | SOURCEANDSINK | M5332R 8
2 x OutPort_5025859 | SOURCEANDSINK | M5332R 8
InPort_5024823 | SOURCEANDSINK | M5332R 7
2 x OutPort_5025885 | SOURCEANDSINK | M5332R 7
Port_5024823 | SOURCEANDSINK | M5332R 7
2 x InPort_5024960 | SOURCEANDSINK | M5332R 7
OutPort_5025587 | SOURCEANDSINK | M5332R 7
Port_5025587 | SOURCEANDSINK | M5332R 7
InPort_5025770 | SOURCEANDSINK | M5332R 7
2 x OutPort_5025893 | SOURCEANDSINK | M5332R 7
Port_5025770 | SOURCEANDSINK | M5332R 7
2 x InPort_5025822 | SOURCEANDSINK | M5332R 8
OutPort_5025847 | SOURCEANDSINK | M5332R 8
Port_5025847 | SOURCEANDSINK | M5332R 8
InPort_5025885 | SOURCEANDSINK | M5332R 7
OutPort_5025886 | SOURCEANDSINK | M5332R 7
InPort_5025886 | SOURCEANDSINK | M5332R 7
InPort_5026155 | SOURCEANDSINK | M533F 10
Port_5026155 | SOURCEANDSINK | M533F 10
2 x InPort_5026235 | SOURCEANDSINK | M5332F 5
2 x OutPort_5026256 | SOURCEANDSINK | M5332F 5
2 x OutPort_5026295 | SOURCEANDSINK | M5332F 5
Port_5026252 | SOURCEANDSINK | M5332F 5
InPort_5026252 | SOURCEANDSINK | M5332F 5
2 x InPort_5026277 | SOURCEANDSINK | M5332F 5
OutPort_5026325 | SOURCEANDSINK | M5332F 5
2 x InPort_5026317 | SOURCEANDSINK | M5332F 5
2 x OutPort_5027038 | SOURCEANDSINK | M5332F 5
OutPort_5027669 | SOURCEANDSINK | M5332F 5
InPort_5026325 | SOURCEANDSINK | M5332F 5
OutPort_5027671 | SOURCEANDSINK | M5332F 5
2 x InPort_5027023 | SOURCEANDSINK | M5332F 5
2 x OutPort_5027046 | SOURCEANDSINK | M5332F 5
2 x InPort_5027040 | SOURCEANDSINK | M5332F 5
2 x OutPort_5027056 | SOURCEANDSINK | M5332F 5
2 x InPort_5027048 | SOURCEANDSINK | M5332F 5
2 x OutPort_5027064 | SOURCEANDSINK | M5332F 5
2 x InPort_5027058 | SOURCEANDSINK | M5332F 5
2 x OutPort_5027313 | SOURCEANDSINK | M5332F 5
2 x InPort_5027141 | SOURCEANDSINK | M5332F 5
OutPort_5027253 | SOURCEANDSINK | M5332F 5
Port_5027253 | SOURCEANDSINK | M5332F 5
InPort_5027313 | SOURCEANDSINK | M5332F 5
OutPort_5027351 | SOURCEANDSINK | M5332F 5
Port_5027351 | SOURCEANDSINK | M5332F 5
2 x Port_5027604 | SOURCEANDSINK | M5332F 6
InPort_5027669 | SOURCEANDSINK | M5332F 5
2 x OutPort_5027684 | SOURCEANDSINK | M5332F 5
InPort_5027671 | SOURCEANDSINK | M5332F 5
InPort_5028769 | SOURCEANDSINK | M524 21
Port_5028769 | SOURCEANDSINK | M524 21
InPort_5028889 | SOURCEANDSINK | M524 20
Port_5028889 | SOURCEANDSINK | M524 20
2 x InPort_5029884 | SOURCEANDSINK | M531 2
2 x OutPort_5030462 | SOURCEANDSINK | M531 2
2 x OutPort_5030441 | SOURCEANDSINK | M531 2
Port_5029890 | SOURCEANDSINK | M531 2
InPort_5029890 | SOURCEANDSINK | M531 2
OutPort_5030410 | SOURCEANDSINK | M531 2
2 x InPort_5030232 | SOURCEANDSINK | M531 2
2 x OutPort_5030246 | SOURCEANDSINK | M531 2
2 x InPort_5030240 | SOURCEANDSINK | M531 2
OutPort_5030254 | SOURCEANDSINK | M531 2
InPort_5030254 | SOURCEANDSINK | M531 2
OutPort_5030296 | SOURCEANDSINK | M531 2
InPort_5030296 | SOURCEANDSINK | M531 2
2 x OutPort_5030381 | SOURCEANDSINK | M531 2
Port_5030333 | SOURCEANDSINK | M531 2
InPort_5030333 | SOURCEANDSINK | M531 2
OutPort_5030343 | SOURCEANDSINK | M531 2
InPort_5030343 | SOURCEANDSINK | M531 2
2 x OutPort_5030383 | SOURCEANDSINK | M531 2
Port_5030364 | SOURCEANDSINK | M531 2
InPort_5030364 | SOURCEANDSINK | M531 2
InPort_5030381 | SOURCEANDSINK | M531 2
InPort_5030410 | SOURCEANDSINK | M531 2
Port_5030527 | SOURCEANDSINK | M531 1
InPort_5030527 | SOURCEANDSINK | M531 1
2 x OutPort_5030725 | SOURCEANDSINK | M531 1
2 x InPort_5030713 | SOURCEANDSINK | M531 1
OutPort_5030733 | SOURCEANDSINK | M531 1
InPort_5030733 | SOURCEANDSINK | M531 1
OutPort_5030807 | SOURCEANDSINK | M531 1
Port_5030807 | SOURCEANDSINK | M531 1
InPort_5030834 | SOURCEANDSINK | M531 3
OutPort_5030965 | SOURCEANDSINK | M531 3
Port_5030834 | SOURCEANDSINK | M531 3
InPort_5030965 | SOURCEANDSINK | M531 3
2 x OutPort_5030979 | SOURCEANDSINK | M531 3
2 x InPort_5030973 | SOURCEANDSINK | M531 3
2 x OutPort_5030992 | SOURCEANDSINK | M531 3
2 x InPort_5030986 | SOURCEANDSINK | M531 3
OutPort_5031132 | SOURCEANDSINK | M531 3
InPort_5031132 | SOURCEANDSINK | M531 3
2 x OutPort_5031344 | SOURCEANDSINK | M531 3
2 x InPort_5031163 | SOURCEANDSINK | M531 3
2 x OutPort_5031343 | SOURCEANDSINK | M531 3
2 x OutPort_5031208 | SOURCEANDSINK | M531 3
Port_5031184 | SOURCEANDSINK | M531 3
InPort_5031184 | SOURCEANDSINK | M531 3
InPort_5031208 | SOURCEANDSINK | M531 3
OutPort_5031223 | SOURCEANDSINK | M531 3
InPort_5031223 | SOURCEANDSINK | M531 3
2 x OutPort_5031241 | SOURCEANDSINK | M531 3
InPort_5031235 | SOURCEANDSINK | M531 3
Port_5031235 | SOURCEANDSINK | M531 3
2 x InPort_5031338 | SOURCEANDSINK | M531 3
2 x OutPort_5031876 | SOURCEANDSINK | M531 3
InPort_5031343 | SOURCEANDSINK | M531 3
2 x InPort_5031868 | SOURCEANDSINK | M531 3
2 x OutPort_5031964 | SOURCEANDSINK | M531 3
2 x InPort_5031886 | SOURCEANDSINK | M531 3
2 x OutPort_5031977 | SOURCEANDSINK | M531 3
2 x InPort_5031967 | SOURCEANDSINK | M531 3
2 x OutPort_5032057 | SOURCEANDSINK | M531 3
2 x InPort_5032000 | SOURCEANDSINK | M531 3
OutPort_5032041 | SOURCEANDSINK | M531 3
Port_5032041 | SOURCEANDSINK | M531 3
2 x InPort_5032880 | SOURCEANDSINK | M524 14
2 x OutPort_5032926 | SOURCEANDSINK | M524 14
InPort_5032904 | SOURCEANDSINK | M524 14
Port_5032904 | SOURCEANDSINK | M524 14
2 x Port_5033534 | SOURCEANDSINK | M570F 8
2 x Port_5034201 | SOURCEANDSINK | M570R 16
2 x Port_5034491 | SOURCEANDSINK | M570F 12

# IfcDistributionPort: VE_Endpiece Roof Ventilator_Ventilator_MEPcontent_Instort Kanalen_Roof ventilator:Dakventilator_100 (2)
Pset_ProductRequirements - Category: Duct Accessories
Name (VE_Endpiece Roof Ventilator_Ventilator_MEPcontent_Instort Kanalen_Roof ventilator:Dakventilator_100:...)
4536891
4536925

# IfcDistributionPort: VE_Endpiece Roof Ventilator_Ventilator_MEPcontent_Instort Kanalen_Roof ventilator:Dakventilator_200 (4)
Pset_ProductRequirements - Category: Duct Accessories
Name (VE_Endpiece Roof Ventilator_Ventilator_MEPcontent_Instort Kanalen_Roof ventilator:Dakventilator_200:...)
4495415
4496922
4496927
4540666

# IfcEnergyConversionDevice: Ronde batterij_315, VE_Battery Heating_Round 2 HC_MEPcontent_LUKA_Heating round:Ronde batterij_315:4484533
In: Dak
Pset_DistributionFlowElementCommon - Reference: Ronde batterij_315; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570F 3

# IfcEnergyConversionDevice: Verwarmingsbatterij_400_400, VE_Battery Heating_Rectangular 2 HC_MEPcontent_LUKA_Heating rect.:Verwarmingsbatterij_400_400:4484528
In: Dak
Pset_DistributionFlowElementCommon - Reference: Verwarmingsbatterij_400_400; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570F 3

# IfcEnergyConversionDevice: Verwarmingsbatterij_450_300, VE_Battery Heating_Rectangular 2 HC_MEPcontent_LUKA_Heating rect.:Verwarmingsbatterij_450_300:4497002
In: Dak
Pset_DistributionFlowElementCommon - Reference: Verwarmingsbatterij_450_300; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570F 16

# IfcFlowController: Brandklep_250, VE_Valve_Round Fire_MEPcontent_LUKA_FPV:Brandklep_250:4459627
In: V00
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Brandklep_250; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570F 1

# IfcFlowController: Kogelkraan RVS_BA2-6652-B_DN20_16 (82)
Type - PredefinedType: REGULATING
Pset_DistributionFlowElementCommon - Reference: Kogelkraan RVS_BA2-6652-B_DN20_16; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Ubel
Pset_PipeConnectionFlanged - FlangeDiameter: 105 mm
Pset_ProductRequirements - Category: Pipe Accessories
Name (M_Valve_Ball_MEPcontent_Ubel_BA2-6652-B:Kogelkraan RVS_BA2-6652-B_DN20_16:...) | In | Group
4968828 | V00 | M5504 1
4968831 | V00 | M5503 1
4968834 | V00 | M5332F 2
4968837 | V00 | M5332R 1
4968840 | V00 | M533F 1
4968843 | V00 | M5337F 1
4968844 | V00 | M5421 1
4968847 | V00 | M5503 1
4968850 | V00 | M5504 1
4970230 | V00 | M5332F 2
4970231 | V00 | M5332R 1
4970232 | V00 | M533F 1
4970233 | V00 | M5337F 1
4970234 | V00 | M5421 1
4972934 | V00 | M533F 1
4981708 | V00 | M5421 1
4981825 | V00 | M5421 1
4993999 | V00 | M533F 1
4994000 | V00 | M5332R 6
4994005 | V00 | M5332F 2
4994010 | V00 | M5421 1
4996137 | V00 | M533F 1
4996142 | V00 | M533F 1
4998491 | V00 | M5337F 1
4998644 | V00 | M5332F 1
4998841 | V00 | M5332R 1
4999007 | V00 | M533F 1
4999113 | V00 | M5337F 1
4999334 | V00 | M5337F 1
4999472 | V00 | M5337F 1
4999690 | V00 | M5421 1
4999693 | V00 | M533F 1
4999696 | V00 | M5332R 1
4999699 | V00 | M5332F 1
5000617 | V00 | M5332F 1
5000620 | V00 | M5332R 1
5000623 | V00 | M533F 1
5000624 | V00 | M5421 1
5000913 | V00 | M533F 6
5001076 | V00 | M5332F 1
5001079 | V00 | M5332R 1
5001082 | V00 | M533F 1
5001085 | V00 | M5332F 1
5001088 | V00 | M5332R 1
5001091 | V00 | M533F 1
5001488 | V00 | M5C01 1
5002755 | V01 | M5332R 4
5002756 | Dak | M5421 1
5002759 | Dak | M533F 7
5003566 | Dak | M5421 1
5003567 | Dak | M5332R 4
5007204 | Dak | M5332R 4
5007205 | Dak | M5332R 4
5007206 | Dak | M5332R 4
5008063 | Dak | M533F 7
5008736 | Dak | M5332R 2
5009655 | Dak | M5332F 4
5010381 | Dak | M533F 9
5012363 | Dak | M533F 9
5012366 | Dak | M533F 9
5012369 | Dak | M533F 9
5013686 | Dak | M533F 3
5014041 | Dak | M533F 3
5014970 | Dak | M5332R 5
5015124 | Dak | M5332R 3
5016351 | Dak | M5421 2
5016712 | Dak | M5421 2
5021166 | Dak | M5332R 5
5021169 | Dak | M5332R 3
5021170 | Dak | M5421 2
5021773 | Dak | M5332R 4
5023192 | Dak | M533F 10
5023292 | Dak | M533F 10
5025587 | Dak | M5332R 7
5025770 | Dak | M5332R 7
5025847 | Dak | M5332R 8
5027253 | Dak | M5332F 5
5027604 | Dak | M5332F 6
5027669 | Dak | M5332F 5
5030441 | Dak | M531 2
5030834 | V01 | M531 3
5032041 | V01 | M531 3

# IfcFlowController: M_, 12_MEPcontent, M_, 12_MEPcontent:M_, 12_MEPcontent:2516572
In: V99
Pset_DistributionFlowElementCommon - Reference: M_, 12_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Pipe Accessories

# IfcFlowController: M_Afsluiter, motorbediend_MEPcontent, M_Afsluiter, motorbediend_MEPcontent:M_Afsluiter, motorbediend_MEPcontent:4434873
In: V00
Pset_DistributionFlowElementCommon - Reference: M_Afsluiter, motorbediend_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Pipe Accessories
Group: M561F 1

# IfcFlowController: M_Afsluiter_MEPcontent (2)
In: V00
Pset_DistributionFlowElementCommon - Reference: M_Afsluiter_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Pipe Accessories
Name (M_Afsluiter_MEPcontent:M_Afsluiter_MEPcontent:...) | Group
4430709 | M561R 1
4430732 | M561F 1

# IfcFlowController: Regelklep_200 (4)
In: V00
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Regelklep_200; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Name (VE_Valve_Round Standard_MEPcontent_LUKA_Control valve:Regelklep_200:...) | Group
4361889 | M570R 1
4361897 | M570R 2
4361905 | M570F 2
4361913 | M570F 2

# IfcFlowController: Regelklep_250, VE_Valve_Round Standard_MEPcontent_LUKA_Control valve:Regelklep_250:4458671
In: V00
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Regelklep_250; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570F 1

# IfcFlowController: Regelklep_315 (11)
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Regelklep_315; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Name (VE_Valve_Round Standard_MEPcontent_LUKA_Control valve:Regelklep_315:...) | In | Group
4459195 | V00 | M570F 9
4459207 | V00 | M570F 11
4459222 | V00 | M570F 13
4459234 | V00 | M570F 15
4484472 | Dak | M570R 1
4484513 | Dak | M570F 3
4484521 | Dak | M570F 3
4496949 | Dak | M570F 18
4496963 | Dak | M570F 20
4496977 | Dak | M570F 23
4496991 | Dak | M570F 25

# IfcFlowController: Regelklep_400_400, VE_Valve_Rectangular Single_MEPcontent_LUKA_Control valve rect.:Regelklep_400_400:4484479
In: Dak
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Regelklep_400_400; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Group: M570R 10

# IfcFlowController: Regelklep_450_300 (4)
Type - PredefinedType: CONTROLDAMPER
Pset_DistributionFlowElementCommon - Reference: Regelklep_450_300; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Accessories
Name (VE_Valve_Rectangular Single_MEPcontent_LUKA_Control valve rect.:Regelklep_450_300:...) | In | Group
4458519 | V00 | M570R 4
4458678 | V00 | M570F 3
4496912 | Dak | M570F 16
4539203 | V01 | M570R 13

# IfcFlowController: SA_, 110_MEPcontent, SA_, 110_MEPcontent:SA_, 110_MEPcontent:2516573
In: V99
Pset_DistributionFlowElementCommon - Reference: SA_, 110_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Pipe Accessories

# IfcFlowController: SA_, 50_MEPcontent, SA_, 50_MEPcontent:SA_, 50_MEPcontent:2516563
In: V99
Pset_DistributionFlowElementCommon - Reference: SA_, 50_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Pipe Accessories

# IfcFlowController: SA_Aansluitpunt_MEPcontent (17)
In: V99
Pset_DistributionFlowElementCommon - Reference: SA_Aansluitpunt_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Pipe Accessories
Name (SA_Aansluitpunt_MEPcontent:SA_Aansluitpunt_MEPcontent:...)
2335977
2515981
2516002
2516023
2516118
2516141
2516168
2516326
2516327
2516328
2516329
2516451
2516511
2516512
2516513
2516514
2516562

# IfcFlowController: Stalen terugslagklep_Fig. 95_DN20_40, M_Valve_Non Return_MEPcontent_Econosto_Fig. 95:Stalen terugslagklep_Fig. 95_DN20_40:4981238
In: V00
Type - PredefinedType: CHECK
Pset_DistributionFlowElementCommon - Reference: Stalen terugslagklep_Fig. 95_DN20_40; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Econosto
Pset_PipeConnectionFlanged - FlangeDiameter: 105 mm
Pset_ProductRequirements - Category: Pipe Accessories
Group: M533F 2

# IfcFlowController: VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_IN (2)
In: V00
Pset_DistributionFlowElementCommon - Reference: VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_IN; sets with these values: 2
Pset_ProductRequirements - Category: Air Terminals
Name (VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_IN:VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_IN:...) | Group
4455754 | M570F 22
4455762 | M570F 2

# IfcFlowController: VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_OUT (4)
Pset_DistributionFlowElementCommon - Reference: VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_OUT; sets with these values: 2
Pset_ProductRequirements - Category: Air Terminals
Name (VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_OUT:VE_Air Terminal_Wall Ventilation Valve Round_MEPcontent_OUT:...) | In | Group
4452611 | V00 | M570R 1
4452615 | V00 | M570R 2
4452619 | V00 | M570R 2
4484538 | Dak | M570R 1

# IfcFlowFitting: 100_300_200, VE_Endpiece Roofend_Circular_MEPcontent:100_300_200:4503838
In: Dak
Type - PredefinedType: EXIT
Pset_DistributionFlowElementCommon - Reference: 100_300_200; sets with these values: 2
Pset_ProductRequirements - Category: Duct Accessories
Group: M570F 14

# IfcFlowFitting: M_Bend_Circular_MEPcontent_VSH XPress Koper_FF (239)
Type - PredefinedType: BEND
Pset_DistributionFlowElementCommon - Reference: M_Bend_Circular_MEPcontent_VSH XPress Koper_FF; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: VSH
Pset_ProductRequirements - Category: Pipe Fittings
Name (M_Bend_Circular_MEPcontent_VSH XPress Koper_FF:M_Bend_Circular_MEPcontent_VSH XPress Koper_FF:...) | In | Group
4957474 | V00 | M5503 1
4958851 | V00 | M5332F 2
4958861 | V00 | M5332F 2
4958881 | V00 | M5332F 2
4959158 | V00 | M5332R 1
4959170 | V00 | M5332R 1
4959188 | V00 | M5332R 1
4959319 | V00 | M533F 1
4959339 | V00 | M533F 1
4959347 | V00 | M533F 1
4959766 | V00 | M5337F 1
4959776 | V00 | M5337F 1
4959794 | V00 | M5337F 1
4968879 | V00 | M5504 1
4968957 | V00 | M5332F 2
4968976 | V00 | M5332R 1
4969027 | V00 | M5337F 1
4969052 | V00 | M5421 1
4969582 | V00 | M5504 1
4969651 | V00 | M5504 1
4969724 | V00 | M5503 1
4969733 | V00 | M5503 1
4969793 | V00 | M5421 1
4969801 | V00 | M5421 1
4969936 | V00 | M5421 1
4971175 | V00 | M533F 1
4971182 | V00 | M533F 1
4971918 | V00 | M5332F 2
4971940 | V00 | M5332R 1
4971960 | V00 | M533F 1
4971982 | V00 | M5337F 1
4972002 | V00 | M5421 1
4972465 | V00 | M5332F 2
4972620 | V00 | M5332R 1
4972730 | V00 | M5421 1
4972732 | V00 | M5421 1
4972763 | V00 | M5337F 1
4972769 | V00 | M5337F 1
4972806 | V00 | M533F 1
4972812 | V00 | M533F 1
4972903 | V00 | M533F 1
4972905 | V00 | M533F 1
4981378 | V00 | M533F 2
4981651 | V00 | M533F 2
4995348 | V00 | M5337F 1
4995350 | V00 | M5337F 1
4995408 | V00 | M5337F 1
4995504 | V00 | M5332R 4
4995506 | V00 | M5332R 4
4995561 | V00 | M5332R 4
4995646 | V00 | M5332F 1
4995648 | V00 | M5332F 1
4995696 | V00 | M5332R 1
4995698 | V00 | M5332R 1
4995772 | V00 | M533F 1
4995774 | V00 | M533F 1
4995858 | V00 | M5421 1
4995860 | V00 | M5421 1
4996064 | V00 | M533F 1
4996066 | V00 | M533F 1
4996300 | V00 | M533F 4
4997025 | V00 | M5332R 4
4997127 | V00 | M5332R 4
4997129 | V00 | M5332R 4
4997289 | V00 | M5332F 1
4997406 | V00 | M5332F 1
4997408 | V00 | M5332F 1
4997496 | V00 | M5332R 1
4997498 | V00 | M5332R 1
4997538 | V00 | M5332R 1
4997600 | V00 | M533F 1
4997602 | V00 | M533F 1
4997706 | V00 | M533F 1
4997838 | V00 | M5421 1
4997840 | V00 | M5421 1
4997862 | V00 | M5421 1
4998044 | V00 | M5421 1
4998166 | V00 | M533F 1
4998168 | V00 | M533F 1
4998279 | V00 | M5332R 1
4998281 | V00 | M5332R 1
4998597 | V00 | M5332F 1
4998599 | V00 | M5332F 1
4998746 | V00 | M5332F 1
4998929 | V00 | M5332R 1
4999027 | V00 | M533F 1
4999214 | V00 | M5337F 1
4999222 | V00 | M5337F 1
4999427 | V00 | M5337F 1
4999492 | V00 | M5337F 1
4999979 | V00 | M533F 1
5000097 | V00 | M5332R 1
5000408 | V00 | M533F 1
5000463 | V00 | M5332R 1
5000925 | V00 | M533F 6
5001103 | V00 | M533F 1
5001122 | V00 | M5332R 1
5001162 | V00 | M533F 1
5001181 | V00 | M5332R 1
5002771 | Dak | M533F 7
5002790 | Dak | M5421 1
5002809 | V01 | M5332R 4
5003583 | Dak | M5421 1
5003737 | Dak | M5332R 4
5004291 | V00 | M5332R 4
5004488 | Dak | M5332R 4
5004753 | V00 | M5337F 1
5004909 | Dak | M5421 1
5004962 | Dak | M533F 7
5005816 | Dak | M5332R 4
5006310 | Dak | M5332R 4
5006368 | Dak | M5421 1
5007072 | Dak | M5332R 4
5007574 | Dak | M533F 7
5007812 | Dak | M533F 7
5008074 | Dak | M533F 7
5008493 | Dak | M5332R 2
5008495 | Dak | M5332R 2
5008644 | Dak | M5332R 2
5008829 | Dak | M5332R 2
5008885 | Dak | M5332R 2
5009389 | Dak | M5332F 3
5009766 | Dak | M5332F 3
5009781 | Dak | M5332F 3
5009783 | Dak | M5332F 3
5009812 | Dak | M5332F 3
5010456 | Dak | M533F 9
5010911 | Dak | M533F 9
5010913 | Dak | M533F 9
5010915 | Dak | M533F 9
5011590 | Dak | M533F 9
5011600 | Dak | M533F 9
5011744 | Dak | M533F 9
5011940 | Dak | M533F 9
5011948 | Dak | M533F 9
5012009 | Dak | M533F 9
5012174 | Dak | M533F 9
5012182 | Dak | M533F 9
5012263 | Dak | M533F 9
5012277 | Dak | M533F 9
5012597 | Dak | M533F 9
5012673 | Dak | M5332R 4
5012692 | Dak | M5421 1
5012709 | Dak | M533F 7
5012728 | Dak | M5332R 2
5012745 | Dak | M5332F 3
5012779 | Dak | M5337F 1
5013100 | V00 | M5421 2
5013125 | V00 | M5332F 2
5013148 | V00 | M5332R 5
5013173 | V00 | M533F 3
5013542 | V00 | M533F 3
5014226 | V01 | M533F 3
5014228 | V01 | M533F 3
5014262 | V00 | M5332R 5
5014863 | Dak | M5332R 5
5014984 | Dak | M5332R 5
5015138 | V00 | M5332F 2
5015453 | Dak | M5332F 2
5015455 | Dak | M5332F 2
5015569 | Dak | M5332F 2
5015571 | Dak | M5332F 2
5016039 | V00 | M5421 2
5017247 | V00 | M5421 1
5017249 | V00 | M5421 1
5017301 | V00 | M5421 1
5017303 | V00 | M5421 1
5017313 | V00 | M5421 1
5017541 | V00 | M533F 1
5017543 | V00 | M533F 1
5017645 | V00 | M533F 1
5017647 | V00 | M533F 1
5017713 | V00 | M533F 1
5018061 | V00 | M5337F 1
5018098 | V00 | M5332R 6
5018238 | V00 | M5332R 6
5018240 | V00 | M5332R 6
5018363 | V00 | M5332R 6
5018376 | V00 | M5332R 6
5018581 | V00 | M533F 1
5018583 | V00 | M533F 1
5018666 | V00 | M5332R 4
5018691 | V00 | M5332R 4
5018693 | V00 | M5332R 4
5018999 | V00 | M5332R 4
5019001 | V00 | M5332R 4
5019225 | V00 | M5421 1
5019232 | V00 | M5421 1
5019440 | V00 | M5332F 2
5019442 | V00 | M5332F 2
5019813 | V00 | M5332F 2
5019820 | V00 | M5332F 2
5020094 | V00 | M5332F 2
5020101 | V00 | M5332F 2
5020110 | V00 | M5332F 2
5020379 | Dak | M5421 2
5020390 | Dak | M5421 2
5020746 | V00 | M5332R 4
5020770 | V00 | M5332R 4
5021391 | Dak | M5332R 4
5021806 | Dak | M5332R 4
5022091 | Dak | M5332R 5
5022101 | Dak | M5332R 5
5022103 | Dak | M5332R 5
5022124 | Dak | M5332R 3
5022136 | Dak | M5332R 3
5022138 | Dak | M5332R 3
5022154 | Dak | M5421 2
5022165 | Dak | M5421 2
5022167 | Dak | M5421 2
5022996 | Dak | M533F 10
5023312 | Dak | M533F 10
5023337 | Dak | M533F 10
5024643 | Dak | M5332R 8
5024721 | Dak | M5332R 8
5025859 | Dak | M5332R 8
5026159 | Dak | M533F 10
5026256 | Dak | M5332F 5
5026295 | Dak | M5332F 5
5026325 | Dak | M5332F 5
5027038 | Dak | M5332F 5
5027046 | Dak | M5332F 5
5027056 | Dak | M5332F 5
5027064 | Dak | M5332F 5
5029890 | Dak | M531 2
5030246 | Dak | M531 2
5030254 | Dak | M531 2
5030343 | Dak | M531 2
5030462 | Dak | M531 2
5030725 | Dak | M531 1
5030733 | Dak | M531 1
5030979 | V01 | M531 3
5030992 | V01 | M531 3
5031132 | V01 | M531 3
5031241 | V01 | M531 3
5031876 | V01 | M531 3
5031964 | V01 | M531 3
5031977 | V00 | M531 3
5032057 | V01 | M531 3

# IfcFlowFitting: M_Reducer_Circular_MEPcontent_VSH XPress Koper_FM (7)
Type - PredefinedType: TRANSITION
Pset_DistributionFlowElementCommon - Reference: M_Reducer_Circular_MEPcontent_VSH XPress Koper_FM; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: VSH
Pset_ProductRequirements - Category: Pipe Fittings
Name (M_Reducer_Circular_MEPcontent_VSH XPress Koper_FM:M_Reducer_Circular_MEPcontent_VSH XPress Koper_FM:...) | In | Group
4972949 | V00 | M533F 1
4981223 | V00 | M533F 1
4981802 | V00 | M5421 1
5001210 | V00 | M5332F 1
5018383 | V00 | M5332R 6
5025893 | Dak | M5332R 7
5027684 | Dak | M5332F 5

# IfcFlowFitting: M_Tee_Circular_MEPcontent_VSH XPress Koper_FFF (47)
Type - PredefinedType: JUNCTION
Pset_DistributionFlowElementCommon - Reference: M_Tee_Circular_MEPcontent_VSH XPress Koper_FFF; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: VSH
Pset_ProductRequirements - Category: Pipe Fittings
Name (M_Tee_Circular_MEPcontent_VSH XPress Koper_FFF:M_Tee_Circular_MEPcontent_VSH XPress Koper_FFF:...) | In | Group
4957489 | V00 | M5504 1
4968936 | V00 | M5503 1
4968995 | V00 | M533F 1
4972034 | V00 | M5332F 2
4972726 | V00 | M5421 1
4972759 | V00 | M5337F 1
4972802 | V00 | M533F 1
4972899 | V00 | M533F 1
4981393 | V00 | M533F 2
4981976 | V00 | M5332R 1
4996060 | V00 | M533F 1
4996168 | V00 | M533F 1
4996315 | V00 | M533F 4
4997285 | V00 | M5332F 1
4997534 | V00 | M5332R 1
4997708 | V00 | M533F 1
4997864 | V00 | M5421 1
4998091 | V00 | M533F 1
4998214 | V00 | M5332R 1
4998335 | V00 | M5332F 1
4998516 | V00 | M5337F 1
4999260 | V00 | M5337F 1
4999392 | V00 | M5337F 1
5000011 | V00 | M533F 1
5000241 | V00 | M5332R 1
5000445 | V00 | M5332R 1
5000482 | V00 | M533F 1
5001141 | V00 | M5332F 1
5001200 | V00 | M5332F 1
5003784 | Dak | M5421 1
5003792 | Dak | M5332R 4
5005529 | Dak | M5332R 4
5006452 | Dak | M5332R 4
5006794 | Dak | M5332R 4
5007576 | Dak | M533F 7
5011746 | Dak | M533F 9
5012038 | Dak | M533F 9
5012279 | Dak | M533F 9
5019401 | V00 | M5421 1
5019873 | V00 | M5332F 2
5020243 | V00 | M5332R 1
5020844 | Dak | M5332R 4
5025885 | Dak | M5332R 7
5027313 | Dak | M5332F 5
5030381 | Dak | M531 2
5031208 | V01 | M531 3
5031343 | V01 | M531 3

# IfcFlowFitting: PVC (2)
In: V00
Pset_DistributionFlowElementCommon - Reference: PVC; sets with these values: 2
Pset_ProductRequirements - Category: Pipe Fittings
Name (SA_Bend_SW_Generic_MEPcontent:PVC:...) | Group
5028780 | M524 21
5028897 | M524 20

# IfcFlowFitting: Recht zadel 90°_90_300_450_300_450, VE_Saddle_Rectangular Sharp_MEPcontent_LUKA_Saddle rect.:Recht zadel 90°_90_300_450_300_450:4540308
In: V00
Type - PredefinedType: JUNCTION
Pset_DistributionFlowElementCommon - Reference: Recht zadel 90°_90_300_450_300_450; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings
Group: M570F 3

# IfcFlowFitting: SA_Bend_Circular_MEPcontent_Onbepaald PVC_1S (11)
Type - PredefinedType: BEND; Material: Color RGB 127-127-127
Classification: SfB]52 (Default Classification)
Pset_DistributionFlowElementCommon - Reference: SA_Bend_Circular_MEPcontent_Onbepaald PVC_1S; sets with these values: 2
Pset_ElementShading - Color: Color RGB 127-127-127; sets with these values: 3
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Fittings
Name (SA_Bend_Circular_MEPcontent_Onbepaald PVC_1S:SA_Bend_Circular_MEPcontent_Onbepaald PVC_1S:...) | In | Group
1685056 | V00 | M524 6
2516019 | V99 | M524 13
2516146 | V99 | M524 13
2516224 | V99 | M524 57
2516324 | V99 | M524 57
2516365 | V99 | M524 23
2516495 | V99 | M524 23
2516505 | V99 | M524 23
2944051 | V00 | M524 16
2944282 | V00 | M524 21
2944300 | V00 | M524 20

# IfcFlowFitting: SA_Bend_Circular_MEPcontent_Onbepaald PVC_2S (28)
Type - PredefinedType: BEND; Material: Color RGB 127-127-127
Classification: SfB]52 (Default Classification)
Pset_DistributionFlowElementCommon - Reference: SA_Bend_Circular_MEPcontent_Onbepaald PVC_2S; sets with these values: 2
Pset_ElementShading - Color: Color RGB 127-127-127; sets with these values: 3
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Fittings
Name (SA_Bend_Circular_MEPcontent_Onbepaald PVC_2S:SA_Bend_Circular_MEPcontent_Onbepaald PVC_2S:...) | In | Group
1685054 | V00 | M524 6
2335956 | V99 | M521 2
2335966 | V99 | M524 2
2515959 | V99 | M524 3
2515975 | V99 | M524 3
2516003 | V99 | M524 11
2516024 | V99 | M524 57
2516026 | V99 | M524 57
2516028 | V99 | M524 46
2516033 | V99 | M521 6
2516108 | V99 | M524 43
2516142 | V99 | M524 13
2516144 | V99 | M524 13
2516218 | V99 | M524 57
2516275 | V99 | M524 57
2516314 | V99 | M524 57
2516322 | V99 | M524 57
2516363 | V99 | M524 23
2516408 | V99 | M524 23
2516503 | V99 | M524 23
2516531 | V99 | M524 27
2516533 | V99 | M524 87
2516568 | V99 | M524 23
2516607 | V99 | M524 87
2944161 | V00 | M524 64
2944280 | V00 | M524 21
2944302 | V00 | M524 20
2948543 | V01 | M524 61

# IfcFlowFitting: SA_Bend_Circular_MEPcontent_Onbepaald PVC_2S short (26)
Type - PredefinedType: BEND; Material: Color RGB 127-127-127
Classification: SfB]52 (Default Classification)
Pset_DistributionFlowElementCommon - Reference: SA_Bend_Circular_MEPcontent_Onbepaald PVC_2S short; sets with these values: 2
Pset_ElementShading - Color: Color RGB 127-127-127; sets with these values: 3
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Fittings
Name (SA_Bend_Circular_MEPcontent_Onbepaald PVC_2S short:SA_Bend_Circular_MEPcontent_Onbepaald PVC_2S short:...) | In | Group
1685062 | V00 | M524 7
1685072 | V00 | M524 8
2335961 | V99 | M521 2
2335971 | V99 | M524 2
2515957 | V99 | M524 3
2515986 | V99 | M524 10
2516005 | V99 | M524 11
2516106 | V99 | M524 43
2516119 | V99 | M524 46
2516131 | V99 | M524 46
2516148 | V99 | M524 13
2516154 | V99 | M524 13
2516169 | V99 | M524 57
2516232 | V99 | M524 57
2516361 | V99 | M524 41
2516410 | V99 | M524 23
2516420 | V99 | M524 23
2516460 | V99 | M524 23
2516523 | V99 | M524 87
2516570 | V99 | M524 23
2944065 | V00 | M524 16
2944075 | V00 | M524 16
2944085 | V00 | M524 16
2944288 | V00 | M524 21
2944298 | V00 | M524 20
2948537 | V00 | M524 61

# IfcFlowFitting: SA_Bend_Composite 2x45_MEPcontent_Onbepaald PVC_2S-1S (6)
Type - Material: Color RGB 127-127-127
Classification: SfB]52 (Default Classification)
Pset_DistributionFlowElementCommon - Reference: SA_Bend_Composite 2x45_MEPcontent_Onbepaald PVC_2S-1S; sets with these values: 2
Pset_ElementShading - Color: Color RGB 127-127-127; sets with these values: 3
Pset_ProductRequirements - Category: Pipe Fittings
Name (SA_Bend_Composite 2x45_MEPcontent_Onbepaald PVC_2S-1S:SA_Bend_Composite 2x45_MEPcontent_Onbepaald PVC_2S-1S:...) | In | Group
2944993 | V99 | M521 1
2948476 | V01 | M524 61
2949047 | V01 | M524 61
2949126 | V01 | M524 61
5032900 | V00 | M524 14
5032926 | V00 | M524 14

# IfcFlowFitting: SA_Reducer_Circular Ring_MEPcontent_Onbepaald PVC_1S (9)
In: V99
Type - PredefinedType: TRANSITION; Material: Color RGB 127-127-127
Classification: SfB]52 (Default Classification)
Pset_DistributionFlowElementCommon - Reference: SA_Reducer_Circular Ring_MEPcontent_Onbepaald PVC_1S; sets with these values: 2
Pset_ElementShading - Color: Color RGB 127-127-127; sets with these values: 3
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Fittings
Name (SA_Reducer_Circular Ring_MEPcontent_Onbepaald PVC_1S:SA_Reducer_Circular Ring_MEPcontent_Onbepaald PVC_1S:...) | Group
2516211 | M524 57
2516268 | M524 57
2516303 | M524 23
2516356 | M524 23
2516401 | M524 23
2516444 | M524 23
2516484 | M524 23
2516557 | M524 87
2516600 | M524 23

# IfcFlowFitting: SA_Tee_Circular_MEPcontent_Onbepaald PVC_3S (14)
Type - PredefinedType: JUNCTION; Material: Color RGB 127-127-127
Classification: SfB]52 (Default Classification)
Pset_DistributionFlowElementCommon - Reference: SA_Tee_Circular_MEPcontent_Onbepaald PVC_3S; sets with these values: 2
Pset_ElementShading - Color: Color RGB 127-127-127; sets with these values: 3
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Fittings
Name (SA_Tee_Circular_MEPcontent_Onbepaald PVC_3S:SA_Tee_Circular_MEPcontent_Onbepaald PVC_3S:...) | In | Group
2515969 | V99 | M524 3
2516021 | V99 | M524 13
2516129 | V99 | M524 46
2516187 | V99 | M524 57
2516226 | V99 | M524 57
2516273 | V99 | M524 57
2516316 | V99 | M524 23
2516406 | V99 | M524 23
2516449 | V99 | M524 23
2516489 | V99 | M524 23
2516497 | V99 | M524 23
2516525 | V99 | M524 87
2516605 | V99 | M524 23
2944053 | V00 | M524 16

# IfcFlowFitting: SA_Tee_Circular_MEPcontent_Onbepaald PVC_Underfloor, SA_Tee_Circular_MEPcontent_Onbepaald PVC_Underfloor:SA_Tee_Circular_MEPcontent_Onbepaald PVC_Underfloor:2944091
In: V00
Type - PredefinedType: JUNCTION; Material: Color RGB 127-127-127
Classification: SfB]52 (Default Classification); Group: M524 16
Pset_DistributionFlowElementCommon - Reference: SA_Tee_Circular_MEPcontent_Onbepaald PVC_Underfloor; sets with these values: 2
Pset_ElementShading - Color: Color RGB 127-127-127; sets with these values: 3
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipe Fittings

# IfcFlowFitting: SA_Tee_Composite Flowing_MEPcontent_Onbepaald PVC_3S-1S-1S-1S (3)
In: V01
Type - Material: Color RGB 127-127-127
Classification: SfB]52 (Default Classification)
Pset_DistributionFlowElementCommon - Reference: SA_Tee_Composite Flowing_MEPcontent_Onbepaald PVC_3S-1S-1S-1S; sets with these values: 2
Pset_ElementShading - Color: Color RGB 127-127-127; sets with these values: 3
Pset_ProductRequirements - Category: Pipe Fittings
Name (SA_Tee_Composite Flowing_MEPcontent_Onbepaald PVC_3S-1S-1S-1S:SA_Tee_Composite Flowing_MEPcontent_Onbepaald PVC_3S-1S-1S-1S:...) | Group
2946985 | M524 16
2948462 | M524 61
2948996 | M524 61

# IfcFlowFitting: VE_Bend_Circular Flowing_MEPcontent_LUKA_Bend (28)
Type - PredefinedType: BEND
Pset_DistributionFlowElementCommon - Reference: VE_Bend_Circular Flowing_MEPcontent_LUKA_Bend; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings
Name (VE_Bend_Circular Flowing_MEPcontent_LUKA_Bend:VE_Bend_Circular Flowing_MEPcontent_LUKA_Bend:...) | In | Group
4452635 | V00 | M570R 1
4452641 | V00 | M570R 2
4452899 | V00 | M570F 2
4455768 | V00 | M570F 2
4458462 | V01 | M570R 3
4484457 | Dak | M570R 1
4484489 | Dak | M570R 1
4484501 | Dak | M570R 1
4496928 | Dak | M570R 15
4496930 | Dak | M570R 15
4537295 | V00 | M570F 5
4537704 | V01 | M570R 3
4539824 | V00 | M570F 1
4540795 | V01 | M570R 5
4545207 | Dak | M570R 1
4558525 | V00 | M570F 2
4558553 | V00 | M570F 2
4558817 | V00 | M570F 2
4558828 | V00 | M570F 2
4559564 | V00 | M570R 1
4559655 | Dak | M570F 3
4561872 | Dak | M570R 11
4561899 | Dak | M570R 11
4562283 | Dak | M570F 3
4562302 | Dak | M570F 3
4915616 | V00 | M570F 4
4915756 | V00 | M570F 4
4915831 | V00 | M570F 4

# IfcFlowFitting: VE_Bend_Rectangular Flowing_MEPcontent_LUKA_Bend rect. (12)
Type - PredefinedType: BEND
Pset_DistributionFlowElementCommon - Reference: VE_Bend_Rectangular Flowing_MEPcontent_LUKA_Bend rect.; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings
Name (VE_Bend_Rectangular Flowing_MEPcontent_LUKA_Bend rect.:VE_Bend_Rectangular Flowing_MEPcontent_LUKA_Bend rect.:...) | In | Group
4484684 | Dak | M570F 3
4485716 | Dak | M570R 10
4497269 | Dak | M570R 4
4508449 | Dak | M570F 3
4537814 | V00 | M570R 4
4542915 | Dak | M570R 8
4552982 | Dak | M570F 3
4552983 | Dak | M570F 3
4553353 | V00 | M570R 4
4555026 | Dak | M570R 12
4556482 | Dak | M570R 10
4556916 | Dak | M570R 7

# IfcFlowFitting: VE_Bend_Rectangular Flowing_MEPcontent_luka_Bend rect._39F4B4F087AE60632E2BB21A6BE38732, VE_Bend_Rectangular Flowing_MEPcontent_luka_Bend rect._39F4B4F087AE60632E2BB21A6BE38732:VE_Bend_Rectangular Flowing_MEPcontent_luka_Bend rect._39F4B4F087AE60632E2BB21A6BE38732:4550299
In: Dak
Type - PredefinedType: BEND
Pset_DistributionFlowElementCommon - Reference: VE_Bend_Rectangular Flowing_MEPcontent_luka_Bend rect._39F4B4F087AE60632E2BB21A6BE38732; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings
Group: M570F 3

# IfcFlowFitting: VE_Bend_Rectangular Flowing_MEPcontent_luka_Bend rect._AEF31FA055DDE526E4433151B32591F8, VE_Bend_Rectangular Flowing_MEPcontent_luka_Bend rect._AEF31FA055DDE526E4433151B32591F8:VE_Bend_Rectangular Flowing_MEPcontent_luka_Bend rect._AEF31FA055DDE526E4433151B32591F8:4513073
In: Dak
Type - PredefinedType: BEND
Pset_DistributionFlowElementCommon - Reference: VE_Bend_Rectangular Flowing_MEPcontent_luka_Bend rect._AEF31FA055DDE526E4433151B32591F8; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings

# IfcFlowFitting: VE_Coupling_Round_MEPcontent_LUKA_Fitting connection, VE_Coupling_Round_MEPcontent_LUKA_Fitting connection:VE_Coupling_Round_MEPcontent_LUKA_Fitting connection:4484540
In: Dak
Type - PredefinedType: CONNECTOR
Pset_DistributionFlowElementCommon - Reference: VE_Coupling_Round_MEPcontent_LUKA_Fitting connection; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings
Group: M570R 1

# IfcFlowFitting: VE_LUKA, Passtuk, 700x400-450x300_MEPcontent, VE_LUKA, Passtuk, 700x400-450x300_MEPcontent:VE_LUKA, Passtuk, 700x400-450x300_MEPcontent:4552936
In: Dak
Pset_DistributionFlowElementCommon - Reference: VE_LUKA, Passtuk, 700x400-450x300_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Group: M570F 3

# IfcFlowFitting: VE_Passtuk, 400x400-200_MEPcontent, VE_Passtuk, 400x400-200_MEPcontent_4aebf16b-4394-45da-90a5-a1f9129e557f:VE_Passtuk, 400x400-200_MEPcontent:4485573
In: Dak
Pset_DistributionFlowElementCommon - Reference: VE_Passtuk, 400x400-200_MEPcontent; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
Group: M570R 8

# IfcFlowFitting: VE_Reducer_Circular Segmented_MEPcontent_LUKA_Centric (5)
Type - PredefinedType: TRANSITION
Pset_DistributionFlowElementCommon - Reference: VE_Reducer_Circular Segmented_MEPcontent_LUKA_Centric; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings
Name (VE_Reducer_Circular Segmented_MEPcontent_LUKA_Centric:VE_Reducer_Circular Segmented_MEPcontent_LUKA_Centric:...) | In | Group
4484564 | Dak | M570R 1
4484580 | Dak | M570R 1
4537702 | Dak | M570R 3
4540793 | V01 | M570R 5
4544932 | V00 | M570R 1

# IfcFlowFitting: VE_Reducer_Rectangular Segmented_MEPcontent_LUKA_Centric rect. (3)
Type - PredefinedType: TRANSITION
Pset_DistributionFlowElementCommon - Reference: VE_Reducer_Rectangular Segmented_MEPcontent_LUKA_Centric rect.; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings
Name (VE_Reducer_Rectangular Segmented_MEPcontent_LUKA_Centric rect.:VE_Reducer_Rectangular Segmented_MEPcontent_LUKA_Centric rect.:...) | In | Group
4538111 | V00 | M570R 4
4542916 | Dak | M570R 8
4555083 | Dak | M570R 12

# IfcFlowFitting: VE_Reducer_Rectangular To Circular Segmented_MEPcontent_LUKA_Reducer rect.-round (3)
Type - PredefinedType: TRANSITION
Pset_DistributionFlowElementCommon - Reference: VE_Reducer_Rectangular To Circular Segmented_MEPcontent_LUKA_Reducer rect.-round; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings
Name (VE_Reducer_Rectangular To Circular Segmented_MEPcontent_LUKA_Reducer rect.-round:VE_Reducer_Rectangular To Circular Segmented_MEPcontent_LUKA_Reducer rect.-round:...) | In | Group
4457937 | V00 | M570F 5
4457979 | V00 | M570F 6
4484675 | Dak | M570F 3

# IfcFlowFitting: VE_Tee_Circular Sharp_MEPcontent_LUKA_T piece (7)
Type - PredefinedType: JUNCTION
Pset_DistributionFlowElementCommon - Reference: VE_Tee_Circular Sharp_MEPcontent_LUKA_T piece; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings
Name (VE_Tee_Circular Sharp_MEPcontent_LUKA_T piece:VE_Tee_Circular Sharp_MEPcontent_LUKA_T piece:...) | In | Group
4449508 | V00 | M570R 1
4452625 | V00 | M570R 2
4452901 | V00 | M570F 2
4484491 | Dak | M570R 1
4484628 | Dak | M570F 3
4545203 | Dak | M570R 1
4559070 | V00 | M570F 2

# IfcFlowFitting: VE_Tee_Rectangular Rounded_MEPcontent_LUKA_T piece rect. (3)
Type - PredefinedType: JUNCTION
Pset_DistributionFlowElementCommon - Reference: VE_Tee_Rectangular Rounded_MEPcontent_LUKA_T piece rect.; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings
Name (VE_Tee_Rectangular Rounded_MEPcontent_LUKA_T piece rect.:VE_Tee_Rectangular Rounded_MEPcontent_LUKA_T piece rect.:...) | In | Group
4508463 | Dak | M570R 12
4513118 | Dak | M570F 3
4538966 | V00 | M570R 4

# IfcFlowFitting: Vlak zadel 90°_90_315_315, VE_Saddle_Rectangular To Circular Rounded_MEPcontent_LUKA_Flat saddle:Vlak zadel 90°_90_315_315:4550464
In: Dak
Type - PredefinedType: JUNCTION
Pset_DistributionFlowElementCommon - Reference: Vlak zadel 90°_90_315_315; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Duct Fittings
Group: M570F 3

# IfcFlowSegment: Pipe Types:Onbepaald PVC_Gladde buis 3m (43)
Pset_DistributionFlowElementCommon - Reference: Onbepaald PVC_Gladde buis 3m; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipes
Name (Pipe Types:Onbepaald PVC_Gladde buis 3m:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1685064 | V00 | 2960 | 3040 | M524 7
1685068 | V00 | 160 | 2840 | M524 8
1685092 | V00 | 200 | 2800 | M524 32
2335973 | V99 | 927.829 | -1186.7 | M524 2
2515961 | V99 | 247.547 | -1535.7 | M524 3
2515971 | V99 | 1510.46 | -1535.7 | M524 3
2515977 | V99 | 3256.89 | -1535.7 | M524 3
2515990 | V99 | 6448.17 | -1535.7 | M524 10
2515994 | V99 | 8020 | -1185.7 | M524 13
2516007 | V99 | 1707.51 | -1535.7 | M524 11
2516011 | V99 | 3888.78 | -1535.7 | M524 11
2516015 | V99 | 11762.7 | -1185.7 | M524 13
2516030 | V99 | 509.892 | -1548 | M521 6
2516037 | V99 | 423 | -1423 | M521 6
2516040 | V99 | 1194.99 | -1548 | M521 8
2516043 | V99 | 1500 | -1423 | M521 9
2516094 | V99 | 1473 | -1446 | M524 39
2516121 | V99 | 1250.58 | -1185.7 | M524 46
2516125 | V99 | 2238.51 | -1185.7 | M524 46
2516133 | V99 | 3706.39 | -1185.7 | M524 46
2516137 | V99 | 1521.31 | -1185.7 | M524 46
2516164 | V99 | 2318.71 | -1185.7 | M524 13
2944055 | V00 | 110 | 2890 | M524 16
2944276 | V00 | 5395.43 | 3014.3 | M524 21
2944284 | V00 | 4622 | 3014.3 | M524 21
2944294 | V00 | 160 | 2840 | M524 20
2944310 | V00 | 710.907 | 2764.3 | M524 20
2944314 | V00 | 4491.69 | 2764.3 | M524 20
2944812 | V00 | 1708 | -1110 | M524 46
2944843 | V99 | 4200 | -1111 | M524 2
2944881 | V99 | 6100 | -1110 | M521 2
2944916 | V99 | 1500 | -1460 | M524 3
2945353 | V00 | 2060 | -1460 | M524 57
2945514 | V00 | 1480 | -1460 | M524 87
2945737 | V00 | 2060 | -1446 | M524 23
2945828 | V00 | 1760 | -1446 | M524 23
2945864 | V99 | 1480 | -1460 | M524 41
2945956 | V99 | 1500 | -1460 | M524 11
2946000 | V99 | 1500 | -1460 | M524 10
2949277 | V00 | 680.113 | 3089.77 | M524 21
2949302 | V00 | 940 | 2800 | M524 74
5028769 | V00 | 4093.5 | -1092 | M524 21 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0; Pset_FlowSegmentPipeSegment - Color: 0
5028889 | V00 | 3843.5 | -1092 | M524 20 | Pset_ElementShading - Color: 0; Pset_FlowSegmentDuctSegment - Color: 0; Pset_FlowSegmentPipeSegment - Color: 0

# IfcFlowSegment: Pipe Types:Onbepaald PVC_Gladde buis 4m (39)
Pset_DistributionFlowElementCommon - Reference: Onbepaald PVC_Gladde buis 4m; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Unspecified
Pset_ProductRequirements - Category: Pipes
Name (Pipe Types:Onbepaald PVC_Gladde buis 4m:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
2335968 | V99 | 2883.58 | -1185.7 | M521 5
2516054 | V99 | 1200 | -1083 | M524 22
2516277 | V99 | 371.225 | -1552.8 | M524 23
2516491 | V99 | 208.225 | -1552.8 | M524 23
2516515 | V99 | 283.524 | -1535.7 | M524 87
2516519 | V99 | 1221.06 | -1535.7 | M524 87
2516527 | V99 | 332.95 | -1523.2 | M524 27
2516564 | V99 | 419.302 | -1552.8 | M524 23
2516574 | V99 | 3065.88 | -1552.8 | M524 23
2516609 | V99 | 351.835 | -1535.7 | M524 87
2516613 | V99 | 2289.24 | -1535.7 | M524 87
2516617 | V99 | 2342.59 | -1552.8 | M524 23
2518510 | V00 | 43 | -85 | M524 44
2586380 | V00 | 43 | -85 | M524 45
2944047 | V00 | 328.877 | 2814.3 | M524 16
2944059 | V00 | 2879.25 | 2814.3 | M524 16
2944067 | V00 | 110 | 2890 | M524 16
2944077 | V00 | 110 | 2890 | M524 16
2944081 | V00 | 3418.09 | 2814.3 | M524 16
2944087 | V00 | 297.94 | 2814.3 | M524 16
2944963 | V99 | 1309.47 | -1535.7 | M521 1
2944980 | V99 | 8121.6 | -1421.6 | M521 1
2945269 | V00 | 1773 | -1463 | M524 57
2945317 | V00 | 1493 | -1463 | M524 57
2945661 | V99 | 2073 | -1473.05 | M524 27
2945695 | V00 | 1633 | -1433 | M524 23
2946970 | V01 | 324.635 | 2814.3 | M524 16
