Properties of the parts of a building model (IFC4)

# File
Description: Option [Bouwkundig: Off], Option [Elektra: On], Option [Sanitair/Verwarming: Off], Option [Ventilatie: Off], Option [Sparingen: Off]
Time: 2021-04-26T10:44:12
Author: HP
Organization: Rcb
Written by: DDS_IFC v3.0
Made in: DDS-CAD Version 16 x64 build 8/12-2020
Authorization: DDS

# IfcProject, 18021c
LongName: Joint Research Center Zeeland

# IfcSite, <Kadaster Gemeente>;<Kadaster nummer>;<Kadaster sectie>
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuilding, JRCZ Middelburg
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey (5)
In: JRCZ Middelburg
Name | Description | Elevation (m)
02 tweede verdieping - 02 tweede verdieping | 02 tweede verdieping - 02 tweede verdieping | 3.7
03 dak - 03 dak | 03 dak - 03 dak | 6
00 begane grond - 00 begane grond | 00 begane grond - 00 begane grond | 0
-1 kelder - -1 kelder | -1 kelder - -1 kelder | -4
01 eerste verdieping - 01 eerste verdieping | 01 eerste verdieping - 01 eerste verdieping | 3

# IfcSpace (24)
PredefinedType: INTERNAL
Name | In | LongName | ElevationWithFlooring (m)
EC-004 | 00 begane grond - 00 begane grond | Sealab - tijdelijke opstellingen | 0
EC-014 | 01 eerste verdieping - 01 eerste verdieping | Sluis | 3
EC-011 | 00 begane grond - 00 begane grond | Opslag buitenruimte | 0
EC-002 | 01 eerste verdieping - 01 eerste verdieping | Verassingsruimte | 3
EC-010 | 00 begane grond - 00 begane grond | Buitenruimte ecologie | 0
AG-07 | 01 eerste verdieping - 01 eerste verdieping | Techniekruimte SER | 3
AG-01 | 00 begane grond - 00 begane grond | Entree | 0
EC-007 | 01 eerste verdieping - 01 eerste verdieping | Steriel laboratorium | 3
EC-016 | 00 begane grond - 00 begane grond | Wasruimte buiten | 0
EC-017 | 01 eerste verdieping - 01 eerste verdieping | Apparatuur en spoelruimte | 3
EC-008 | 00 begane grond - 00 begane grond | Wasruimte | 0
AG-03 | 01 eerste verdieping - 01 eerste verdieping | Toilet | 3
EC-006 | 00 begane grond - 00 begane grond | Klimaatkamer | 0
EC-009 | 00 begane grond - 00 begane grond | Magazijn | 0
AG-02 | 00 begane grond - 00 begane grond | MIVA | 0
EC-018 | 00 begane grond - 00 begane grond | Opslag chemicaliën | 0
EC-012 | 00 begane grond - 00 begane grond | Opslag zoutwater | 0
EC-013 | 00 begane grond - 00 begane grond | Zoutwaterinstallatie | 0
EC-015 | 00 begane grond - 00 begane grond | Douche | 0
EC-005 | 00 begane grond - 00 begane grond | Klimaatkamer | 0
EC-003 | 02 tweede verdieping - 02 tweede verdieping | Sealab - vaste opstellingen | 3.7
AG-08 | 00 begane grond - 00 begane grond | Meterkast | 0
AG-04 | 00 begane grond - 00 begane grond | Werkkast | 0
3 | -1 kelder - -1 kelder | BC 01 | -4

# IfcAnnotation (3)
In: 01 eerste verdieping - 01 eerste verdieping
Description: class DdsPrimitivePolyline

# IfcDistributionPort (176)
FlowDirection: SINK; PredefinedType: CABLE; SystemType: ELECTRICAL

# IfcDistributionSystem: #ELS, Noodverlichtingsinstallatie
PredefinedType: USERDEFINED

# IfcLightFixture: Lamp (Divers) (9)
Type - Description: A1; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421142259; ModelReference: A1; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421142259
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.182609 A; ActualVoltage: 0 V
Name | In | RoomNumber | RoomDescription
2 x Lamp (Divers) | EC-004 | EC-004 | Sealab - tijdelijke opstellingen
3 x Lamp (Divers) | 01 eerste verdieping - 01 eerste verdieping
2 x Lamp (Divers) | EC-007 | EC-007 | Steriel laboratorium
2 x Lamp (Divers) | EC-017 | EC-017 | Apparatuur en spoelruimte

# IfcLightFixture: Lamp (Divers) (54)
Type - Description: A2; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421142522; ModelReference: A2; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421142522
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.182609 A; ActualVoltage: 0 V
Name | In | RoomNumber | RoomDescription
18 x Lamp (Divers) | EC-004 | EC-004 | Sealab - tijdelijke opstellingen
25 x Lamp (Divers) | 01 eerste verdieping - 01 eerste verdieping
5 x Lamp (Divers) | EC-007 | EC-007 | Steriel laboratorium
6 x Lamp (Divers) | EC-017 | EC-017 | Apparatuur en spoelruimte

# IfcLightFixture: Lamp (Divers) (6)
Type - Description: A4; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421142647; ModelReference: A4; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421142647
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.182609 A; ActualVoltage: 0 V
Name | In | RoomNumber | RoomDescription
2 x Lamp (Divers) | EC-014 | EC-014 | Sluis
2 x Lamp (Divers) | EC-002 | EC-002 | Verassingsruimte
2 x Lamp (Divers) | AG-07 | AG-07 | Techniekruimte SER

# IfcLightFixture: Lamp (Divers) (4)
Type - Description: C; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421141503; ModelReference: C; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421141503
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.0565217 A; ActualVoltage: 0 V
Name | In | RoomNumber | RoomDescription
2 x Lamp (Divers) | AG-03 | AG-03 | Toilet
2 x Lamp (Divers) | AG-02 | AG-02 | MIVA

# IfcLightFixture: Lamp (Divers)
In: EC-015
Type - Description: D1; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421141854; ModelReference: D1; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421141854
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_RoomPlacement - RoomNumber: EC-015; RoomDescription: Douche
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.0565217 A; ActualVoltage: 0 V

# IfcLightFixture: Lamp (Divers) (11)
Type - Description: E2 1263; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421143314; ModelReference: E2 1263; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421143314
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.182609 A; ActualVoltage: 0 V
Name | In | RoomNumber | RoomDescription
2 x Lamp (Divers) | EC-011 | EC-011 | Opslag buitenruimte
4 x Lamp (Divers) | -1 kelder - -1 kelder
2 x Lamp (Divers) | EC-018 | EC-018 | Opslag chemicaliën
Lamp (Divers) | EC-012 | EC-012 | Opslag zoutwater
2 x Lamp (Divers) | EC-013 | EC-013 | Zoutwaterinstallatie

# IfcLightFixture: Lamp (Divers) (5)
Type - Description: H; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421143853; ModelReference: H; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421143853
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.413043 A; ActualVoltage: 0 V
Name | In | RoomNumber | RoomDescription
Lamp (Divers) | EC-006 | EC-006 | Klimaatkamer
3 x Lamp (Divers) | EC-009 | EC-009 | Magazijn
Lamp (Divers) | EC-005 | EC-005 | Klimaatkamer

# IfcLightFixture: Lamp (Divers) (2)
In: EC-008
Type - Description: J; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421144114; ModelReference: J; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421144114
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_RoomPlacement - RoomNumber: EC-008; RoomDescription: Wasruimte
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.217391 A; ActualVoltage: 0 V

# IfcLightFixture: Lamp (Divers) (14)
Type - Description: NB; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421153213; ModelReference: NB; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421153213
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.0565217 A; ActualVoltage: 0 V
Name | In
4 x Lamp (Divers) | 01 eerste verdieping - 01 eerste verdieping
Lamp (Divers) | EC-007 | DDS_Pset_RoomPlacement - RoomNumber: EC-007; RoomDescription: Steriel laboratorium
Lamp (Divers) | EC-017 | DDS_Pset_RoomPlacement - RoomNumber: EC-017; RoomDescription: Apparatuur en spoelruimte
2 x Lamp (Divers) | 00 begane grond - 00 begane grond
3 x Lamp (Divers) | -1 kelder - -1 kelder
Lamp (Divers) | EC-004 | DDS_Pset_RoomPlacement - RoomNumber: EC-004; RoomDescription: Sealab - tijdelijke opstellingen
Lamp (Divers) | EC-002 | DDS_Pset_RoomPlacement - RoomNumber: EC-002; RoomDescription: Verassingsruimte
Lamp (Divers) | EC-018 | DDS_Pset_RoomPlacement - RoomNumber: EC-018; RoomDescription: Opslag chemicaliën

# IfcLightFixture: Lamp (Divers) (5)
Type - Description: NC; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421153252; ModelReference: NC; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421153252
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.0565217 A; ActualVoltage: 0 V
Name | In
3 x Lamp (Divers) | 01 eerste verdieping - 01 eerste verdieping
2 x Lamp (Divers) | 00 begane grond - 00 begane grond

# IfcLightFixture: Lamp (Divers) (2)
Type - Description: ND; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421153352; ModelReference: ND; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421153352
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.0565217 A; ActualVoltage: 0 V
Name | In | RoomNumber | RoomDescription
Lamp (Divers) | EC-008 | EC-008 | Wasruimte
Lamp (Divers) | AG-02 | AG-02 | MIVA

# IfcLightFixture: Lamp (Divers) (8)
Type - Description: NF; PredefinedType: SECURITYLIGHTING
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421152451; ModelReference: NF; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 81; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421152451
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.026087 A; ActualVoltage: 0 V
Group: Noodverlichtingsinstallatie
Name | In
7 x Lamp (Divers) | 00 begane grond - 00 begane grond
Lamp (Divers) | EC-010 | DDS_Pset_RoomPlacement - RoomNumber: EC-010; RoomDescription: Buitenruimte ecologie

# IfcLightFixture: Lamp (Divers) (7)
Type - Description: Noodverlichtingsarmatuur rechtdoor of naar boven (ISO 7010); PredefinedType: SECURITYLIGHTING
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-140403-001; ModelReference: Noodverlichtingsarmatuur rechtdoor of naar boven (ISO 7010); Manufacturer: NLD
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 80; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-140403-001
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.0478261 A; ActualVoltage: 0 V
Group: Noodverlichtingsinstallatie
Name | In
2 x Lamp (Divers) | AG-01 | DDS_Pset_RoomPlacement - RoomNumber: AG-01; RoomDescription: Entree
3 x Lamp (Divers) | 01 eerste verdieping - 01 eerste verdieping
Lamp (Divers) | EC-004 | DDS_Pset_RoomPlacement - RoomNumber: EC-004; RoomDescription: Sealab - tijdelijke opstellingen
Lamp (Divers) | 00 begane grond - 00 begane grond

# IfcLightFixture: Lamp (Divers) (9)
Type - Description: S; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-230421133118; ModelReference: S; Manufacturer: NLD
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-230421133118
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.434783 A; ActualVoltage: 0 V
Name | In
3 x Lamp (Divers) | JRCZ Middelburg
2 x Lamp (Divers) | EC-010 | DDS_Pset_RoomPlacement - RoomNumber: EC-010; RoomDescription: Buitenruimte ecologie
2 x Lamp (Divers) | EC-016 | DDS_Pset_RoomPlacement - RoomNumber: EC-016; RoomDescription: Wasruimte buiten
2 x Lamp (Divers) | 01 eerste verdieping - 01 eerste verdieping

# IfcLightFixture: Lamp (Divers) (5)
Type - Description: S +sn; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-230421133046; ModelReference: S +sn; Manufacturer: NLD
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-230421133046
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.434783 A; ActualVoltage: 0 V
Name | In
2 x Lamp (Divers) | EC-010 | DDS_Pset_RoomPlacement - RoomNumber: EC-010; RoomDescription: Buitenruimte ecologie
Lamp (Divers) | JRCZ Middelburg
2 x Lamp (Divers) | 01 eerste verdieping - 01 eerste verdieping

# IfcLightFixture: Lamp (Divers) (8)
Type - Description: T; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421145301; ModelReference: T; Manufacturer: NLD
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421145301
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.434783 A; ActualVoltage: 0 V
Name | In
4 x Lamp (Divers) | 01 eerste verdieping - 01 eerste verdieping
2 x Lamp (Divers) | AG-01 | DDS_Pset_RoomPlacement - RoomNumber: AG-01; RoomDescription: Entree
2 x Lamp (Divers) | 00 begane grond - 00 begane grond

# IfcLightFixture: Lamp (Divers) (7)
Type - Description: V; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421145535; ModelReference: V; Manufacturer: NLD
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421145535
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.434783 A; ActualVoltage: 0 V
Name | In
4 x Lamp (Divers) | 00 begane grond - 00 begane grond
3 x Lamp (Divers) | 01 eerste verdieping - 01 eerste verdieping

# IfcLightFixture: Lamp (Divers) (2)
In: 00 begane grond - 00 begane grond
Type - Description: W; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421145647; ModelReference: W; Manufacturer: NLD
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421145647
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.434783 A; ActualVoltage: 0 V

# IfcLightFixture: Lamp (Divers) (11)
In: 00 begane grond - 00 begane grond
Type - Description: X; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-220421145838; ModelReference: X; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-220421145838
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.434783 A; ActualVoltage: 0 V

# IfcLightFixture: Lamp (Divers) (6)
In: 01 eerste verdieping - 01 eerste verdieping
Type - Description: Z; PredefinedType: POINTSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: LI-230421144815; ModelReference: Z; Manufacturer: DDS
Type - DDS_Pset_ElectricalCostData - Location: NOR; SystemCodeName: NS3451; SystemCodeValue: 8; ProductCodeName: NS3420; ProductCodeValue: U31; CostCodeName: Eldata Kode; CostCodeValue: LI-230421144815
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no
DDS_Pset_ElectricalLoadOccurrence - ActualCurrent: 0.195652 A; ActualVoltage: 0 V
