Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcElementAssembly (688)
Name | LOAD_BEARING | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Kolom | Nee | 149.2 | -0.050 | +6.004 | C-D/1 | A0(?) | 140
Kolom | Nee | 98.2 | -0.050 | +3.932 | E-F/1-2 | A0(?) | 140
Kolom | Nee | 77.8 | -0.050 | +3.105 | E-F/1 | A0(?) | 140
2 x Kolom | Nee | 157.7 | -0.050 | +6.345 | E-F/2 | A0(?) | 140
Kolom | Nee | 97.8 | -0.050 | +3.920 | K-G/5 | A0(?) | 140
Kolom | Nee | 102.1 | -0.050 | +4.092 | G-H/T-5 | A0(?) | 140
Kolom | Nee | 101.6 | -0.050 | +4.073 | G-H/1-2 | A0(?) | 140
Kolom | Nee | 101.6 | -0.050 | +4.073 | K-G/1-2 | A0(?) | 140
Kolom | Nee | 95.4 | -0.050 | +3.820 | E-F/1-2 | A0(?) | 140
Kolom | Nee | 78.7 | +3.152 | +6.345 | V/2-L | A-20(?) | 140
Kolom | Nee | 99.1 | -0.050 | +3.970 | G-H/N | A0(?) | 140
Kolom | Nee | 79.2 | -0.050 | +3.163 | H/M-N | A0(?) | 140
Kolom | Nee | 101.6 | -0.050 | +4.072 | G-H/M | A0(?) | 140
Kolom | Nee | 79.2 | -0.050 | +3.164 | G-H/3 | A0(?) | 140
Kolom | Nee | 101.4 | -0.050 | +4.063 | G-H/S | A0(?) | 140
Kolom | Nee | 102.1 | -0.050 | +4.095 | G-H/R | A0(?) | 140
Kolom | Nee | 80 | -0.050 | +3.197 | H/R-S | A0(?) | 140
Kolom | Nee | 78.8 | -0.050 | +3.149 | G-H/S-T | A0(?) | 140
Kolom | Nee | 164.9 | -0.050 | +5.369 | G-H/R-S | A0(?) | 160
Kolom | Nee | 164.9 | -0.050 | +5.368 | G-H/M-N | A0(?) | 160
Kolom | Nee | 79.2 | -0.050 | +3.161 | K-G/5-6 | A0(?) | 140
Kolom | Nee | 80.1 | -0.050 | +3.198 | G-H/T-5 | A0(?) | 140
Kolom | Nee | 79.2 | -0.050 | +3.161 | G-H/1-2 | A0(?) | 140
Kolom | Nee | 187 | -0.070 | +6.070 | E/P | A0(?) | 160
Kolom | Nee | 187 | -0.070 | +6.070 | E/M-N | A0(?) | 160
Kolom | Nee | 138.1 | -0.050 | +5.436 | I/T-5 | A0(?) | 168.3
Kolom | Nee | 66.1 | -0.050 | +3.144 | J/5-6 | A0(?) | 139.7
Kolom | Nee | 146.1 | -0.050 | +5.754 | K-G/T-5 | A0(?) | 168.3
Kolom | Nee | 66.5 | -0.050 | +3.160 | G-H/5-6 | A0(?) | 139.7
Kolom | Nee | 146.2 | -0.050 | +5.758 | G-H/S-T | A0(?) | 168.3
Kolom | Nee | 66.5 | -0.050 | +3.160 | G-H/T-5 | A0(?) | 139.7
Kolom | Nee | 66.5 | -0.050 | +3.160 | G-H/2 | A0(?) | 139.7
Kolom | Nee | 139 | -0.050 | +5.471 | K-G/2 | A0(?) | 168.3
Kolom | Nee | 66.5 | -0.050 | +3.160 | G-H/1-2 | A0(?) | 139.7
Kolom | Nee | 66.5 | -0.050 | +3.161 | J/1-2 | A0(?) | 139.7
Kolom | Nee | 149.2 | -0.050 | +6.004 | D-E/1 | A0(?) | 140

# IfcFastener (39)
In: Undefined
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Tekla Weld Common - Volume: 0 m3; NDT inspection level: Geen; Electrode coefficent: 0; Electrode strength: 0; Electrode classification: Geen; Process type: Geen; Weld number: 0; Assembly type: Werkplaats; Intermittent type: Doorlopend; Edge/Around: Rand
Tekla Weld Above Line - Cross section area1: 0.00001 m2; Increment count1: 0; Pitch1: 0; Length1: 0 mm; Finish1: Geen; Fill type1: Geen; Root face thickness1: 0 mm; Root opening1: 0 mm; Weld angle1: 0; Effective throat1: 0 mm; Size1: 3 mm; Type1: Hoeklas
Tekla Weld Below Line - Cross section area2: 0.00001 m2; Increment count2: 0; Pitch2: 0; Length2: 0 mm; Finish2: Geen; Fill type2: Geen; Root face thicness2: 0 mm; Root opening2: 0 mm; Weld angle2: 0; Effective throat2: 0 mm; Size2: 3 mm; Type2: Hoeklas
Name | Length (mm) = Actual length1 (mm) | Actual length2 (mm)
9 x Weld | 22 | 20.3
7 x Weld | 116 | 116
14 x Weld | 140 | 134.5
9 x Weld | 22 | 20.6

# IfcMechanicalFastener: Bolt assembly (13)
In: Undefined
NominalDiameter: 16 mm; NominalLength: 15 mm; Material: Undefined
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Tekla Bolt - Phase: 230; Washer count: 0; Washer diameter: 16 mm; Washer type: 7089; Washer name: RING-M16-7089; Nut count: 0; Nut type: 4032; Nut name: MOER-M16-4032; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Bolt hole diameter: 20 mm; Location: Montage; Bolt count: 4; Bolt size: 20 mm; Bolt length: 15 mm; Bolt standard: 4014-8.8; Bolt Name: BOUT

# IfcMember: 110*12 (8)
In: Undefined
Description: 110*12; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Tekla Common - Phase: 1010; Class: 14
Tekla Quantity - Gross footprint area: 0 m2; Height: 12 mm; Width: 110 mm
Pset_MemberCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
BaseQuantities - CrossSectionArea: 0.00132 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) = GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x Windverband | +3.042 | +4.262 | 13.37 | 0.002 | 23.745 | 0.318 | 1290.5 | 1290.53 | 0.317529 | 0.0017035 | 13.3724 | 13.3724
2 x Windverband | +3.018 | +4.301 | 33.25 | 0.004 | 23.627 | 0.786 | 3209.3 | 3209.31 | 0.785712 | 0.00423629 | 33.2549 | 33.2549
Windverband | +3.019 | +4.291 | 28.73 | 0.004 | 23.644 | 0.679 | 2797.8 | 2797.82 | 0.679248 | 0.00365961 | 28.728 | 28.991
Windverband | +3.013 | +4.306 | 33.56 | 0.004 | 23.627 | 0.793 | 3238.8 | 3238.78 | 0.792902 | 0.00427519 | 33.5602 | 33.5602
Windverband | +3.017 | +4.316 | 34.16 | 0.004 | 23.625 | 0.807 | 3296.9 | 3296.93 | 0.807092 | 0.00435195 | 34.1628 | 34.1628
Windverband | +3.015 | +4.289 | 28.6 | 0.004 | 23.64 | 0.676 | 2760.5 | 2760.54 | 0.676213 | 0.00364392 | 28.6048 | 28.6048

# IfcMember: 80*8 (12)
In: Undefined
Description: 80*8; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_MemberCommon - IsExternal: no; LoadBearing: no
Tekla Common - Phase: 1010
Tekla Quantity - Gross footprint area: 0 m2; Height: 8 mm; Width: 80 mm
BaseQuantities - CrossSectionArea: 0.00064 m2
Name | Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Volume (m3) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) = GrossVolume (m3) | NetWeight (kg) = GrossWeight (kg)
Windverband | A0(?) | +4.253 | +5.990 | 14 | 14.08 | 0.002 | 35.123 | 0.495 | 2802.4 | 2802.41 | 0.494504 | 0.00179354 | 14.0793
Windverband | A0(?) | +4.255 | +6.002 | 14 | 17.03 | 0.002 | 35.107 | 0.598 | 3390.4 | 3390.37 | 0.597984 | 0.00216983 | 17.0332
2 x Windverband | A0(?) | -0.080 | +2.908 | 7 | 22.09 | 0.003 | 35.09 | 0.775 | 4397.5 | 4397.48 | 0.775236 | 0.00281438 | 22.0929
Windverband | A0(?) | -0.076 | +3.896 | 7 | 26.1 | 0.003 | 35.081 | 0.916 | 5195.9 | 5195.94 | 0.915766 | 0.0033254 | 26.1044
Windverband | A0(?) | -0.081 | +2.901 | 7 | 22.77 | 0.003 | 35.087 | 0.799 | 4531.3 | 4531.33 | 0.798794 | 0.00290005 | 22.7654
Windverband | A0(?) | -0.076 | +4.046 | 7 | 26.79 | 0.003 | 35.08 | 0.94 | 5331.3 | 5331.27 | 0.939584 | 0.00341202 | 26.7843
Windverband | A0(?) | -0.080 | +3.050 | 7 | 23.38 | 0.003 | 35.087 | 0.82 | 4654.2 | 4654.16 | 0.820413 | 0.00297867 | 23.3825
Windverband | A-20(?) | +2.843 | +5.906 | 7 | 22.35 | 0.003 | 35.089 | 0.784 | 4448.6 | 4448.62 | 0.784238 | 0.00284712 | 22.3499
Windverband | A-20(?) | +2.889 | +5.926 | 7 | 22.26 | 0.003 | 35.089 | 0.781 | 4430.4 | 4430.4 | 0.78103 | 0.00283545 | 22.2583
2 x Windverband | A0(?) | -0.048 | +2.944 | 7 | 26.9 | 0.003 | 35.08 | 0.944 | 5357.3 | 5357.26 | 0.944157 | 0.00342864 | 26.9149

# IfcMember: K80/3 (6)
In: Undefined
Description: K80/3; Material: STEEL/S275JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_MemberCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Tekla Common - Phase: 1010; Class: 9
Tekla Quantity - Area per tons: 43.492 m2; Height: 80 mm; Width: 80 mm
BaseQuantities - CrossSectionArea: 0.000908 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
Koppelkoker | +3.168 | +3.269 | 23.61 | 0.003 | 0 | 1.061 | 3312.3 | 3312.29 | 1.02681 | 0.00306055 | 0.00300756 | 24.0253 | 23.6093
2 x Koppelkoker | +2.782 | +3.160 | 12.91 | 0.002 | 0 | 0.581 | 1812 | 1812.02 | 0.561725 | 0.0016743 | 0.00164531 | 13.1433 | 12.9157
2 x Koppelkoker | +2.782 | +2.862 | 22.17 | 0.003 | 0.249 | 0.996 | 3110.4 | 3110.41 | 0.964227 | 0.00287402 | 0.00282425 | 22.561 | 22.1704
Koppelkoker | +3.182 | +3.262 | 20.45 | 0.003 | 0.229 | 0.919 | 2868.3 | 2868.31 | 0.889176 | 0.00265032 | 0.00260442 | 20.805 | 20.4447

# IfcMember: STRIP8*80 (82)
In: Undefined
Description: STRIP8*80; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Tekla Common - Phase: 1010; Class: 7
Tekla Quantity - Gross footprint area: 0 m2; Height: 80 mm; Width: 8 mm
Pset_MemberCommon - IsExternal: no; LoadBearing: no
BaseQuantities - CrossSectionArea: 0.00064 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) = GrossVolume (m3) | NetWeight (kg) = GrossWeight (kg)
Windverband | +3.055 | +6.408 | 25.81 | 0.003 | 35.081 | 0.906 | 5138.3 | A-20(?) | 5138.29 | 0.905619 | 0.0032885 | 25.8148
Windverband | +2.912 | +6.363 | 26.79 | 0.003 | 35.08 | 0.94 | 5332.1 | A-20(?) | 5332.09 | 0.939728 | 0.00341254 | 26.7884
Windverband | +2.901 | +2.939 | 19.99 | 0.003 | 35.096 | 0.702 | 3979.9 | A0(?) | 3979.89 | 0.701741 | 0.00254713 | 19.995
Windverband | +2.901 | +2.939 | 20.94 | 0.003 | 35.093 | 0.735 | 4168.4 | A0(?) | 4168.38 | 0.734915 | 0.00266776 | 20.9419
Windverband | +2.836 | +2.909 | 26.96 | 0.003 | 35.08 | 0.946 | 5365.7 | A0(?) | 5365.7 | 0.945643 | 0.00343405 | 26.9573
Windverband | +2.836 | +2.909 | 27.09 | 0.003 | 35.08 | 0.95 | 5392.4 | A0(?) | 5392.41 | 0.950345 | 0.00345114 | 27.0915
Windverband | +2.954 | +6.402 | 26.9 | 0.003 | 35.08 | 0.944 | 5354.1 | A-20(?) | 5354.07 | 0.943597 | 0.00342661 | 26.8989
Windverband | +2.811 | +6.357 | 27.21 | 0.003 | 35.08 | 0.955 | 5417 | A-20(?) | 5416.95 | 0.954663 | 0.00346685 | 27.2148
Windverband | +2.886 | +6.401 | 26.09 | 0.003 | 35.081 | 0.915 | 5192.4 | A-20(?) | 5192.43 | 0.915147 | 0.00332315 | 26.0867
Windverband | +2.885 | +6.051 | 24.95 | 0.003 | 35.083 | 0.875 | 4965.9 | A-20(?) | 4965.86 | 0.875271 | 0.00317815 | 24.9485
Windverband | -0.100 | +3.032 | 23.03 | 0.003 | 35.087 | 0.808 | 4584.1 | A0(?) | 4584.05 | 0.808073 | 0.00293379 | 23.0303
Windverband | -0.100 | +3.031 | 23.03 | 0.003 | 35.087 | 0.808 | 4583.7 | A0(?) | 4583.72 | 0.808014 | 0.00293358 | 23.0286
Windverband | -0.088 | +4.282 | 24.53 | 0.003 | 35.084 | 0.861 | 4882.1 | A0(?) | 4882.11 | 0.860532 | 0.00312455 | 24.5277
Windverband | +3.031 | +4.352 | 10.19 | 0.001 | 35.157 | 0.358 | 2027.9 | A0(?) | 2027.92 | 0.358194 | 0.00129787 | 10.1883
Windverband | +3.031 | +4.351 | 10.19 | 0.001 | 35.157 | 0.358 | 2027.6 | A0(?) | 2027.61 | 0.358139 | 0.00129767 | 10.1867
Windverband | -0.091 | +3.084 | 18.65 | 0.002 | 35.1 | 0.655 | 3711.8 | A0(?) | 3711.75 | 0.654549 | 0.00237552 | 18.6478
Windverband | -0.091 | +3.084 | 18.65 | 0.002 | 35.1 | 0.654 | 3711.3 | A0(?) | 3711.33 | 0.654474 | 0.00237525 | 18.6457
Windverband | -0.088 | +3.081 | 17.65 | 0.002 | 35.104 | 0.62 | 3513.5 | A0(?) | 3513.47 | 0.61965 | 0.00224862 | 17.6517
Windverband | -0.088 | +3.080 | 17.65 | 0.002 | 35.104 | 0.62 | 3513 | A0(?) | 3513.02 | 0.619572 | 0.00224833 | 17.6494
Windverband | -0.097 | +3.080 | 21.51 | 0.003 | 35.09 | 0.755 | 4282.2 | A0(?) | 4282.15 | 0.754939 | 0.00274058 | 21.5135
Windverband | -0.098 | +3.040 | 21.36 | 0.003 | 35.092 | 0.75 | 4252.6 | A0(?) | 4252.56 | 0.749731 | 0.00272164 | 21.3649
2 x Windverband | +3.053 | +5.539 | 17.96 | 0.002 | 35.104 | 0.631 | 3575.2 | A-20(?) | 3575.18 | 0.630512 | 0.00228812 | 17.9617
2 x Windverband | +3.053 | +5.539 | 17.96 | 0.002 | 35.104 | 0.631 | 3575.5 | A-20(?) | 3575.49 | 0.630566 | 0.00228831 | 17.9632
2 x Windverband | +3.053 | +5.539 | 17.96 | 0.002 | 35.104 | 0.63 | 3574.1 | A-20(?) | 3574.07 | 0.630316 | 0.0022874 | 17.9561
2 x Windverband | +3.059 | +5.534 | 15.08 | 0.002 | 35.117 | 0.53 | 3001.6 | A-20(?) | 3001.65 | 0.52957 | 0.00192106 | 15.0803
Windverband | +3.059 | +5.534 | 15.08 | 0.002 | 35.117 | 0.53 | 3002 | A-20(?) | 3001.97 | 0.529627 | 0.00192126 | 15.0819
Windverband | +3.059 | +5.534 | 15.08 | 0.002 | 35.117 | 0.53 | 3002 | A-20(?) | 3001.99 | 0.52963 | 0.00192127 | 15.082
Windverband | +3.053 | +5.539 | 17.98 | 0.002 | 35.104 | 0.631 | 3578.2 | A0(?) | 3578.23 | 0.631049 | 0.00229007 | 17.9771
Windverband | +3.053 | +5.539 | 17.98 | 0.002 | 35.104 | 0.631 | 3578.2 | A0(?) | 3578.24 | 0.63105 | 0.00229007 | 17.9771
2 x Windverband | +3.053 | +5.539 | 17.96 | 0.002 | 35.104 | 0.631 | 3577.7 | A0(?) | 3577.75 | 0.630964 | 0.00228976 | 17.9746
Windverband | -0.093 | +4.286 | 26.47 | 0.003 | 35.08 | 0.929 | 5269.7 | A0(?) | 5269.65 | 0.928739 | 0.00337258 | 26.4747
Windverband | -0.076 | +6.096 | 40.39 | 0.005 | 35.064 | 1.416 | 8038.7 | A0(?) | 8038.67 | 1.41609 | 0.00514475 | 40.3863
Windverband | -0.076 | +6.096 | 40.39 | 0.005 | 35.064 | 1.416 | 8038.3 | A0(?) | 8038.29 | 1.41602 | 0.00514451 | 40.3844
Windverband | -0.081 | +3.103 | 24.58 | 0.003 | 35.084 | 0.862 | 4891.8 | A0(?) | 4891.81 | 0.862238 | 0.00313076 | 24.5764
Windverband | -0.081 | +3.073 | 24.48 | 0.003 | 35.084 | 0.859 | 4872.3 | A0(?) | 4872.27 | 0.858799 | 0.00311825 | 24.4783
Windverband | -0.080 | +3.166 | 24.39 | 0.003 | 35.084 | 0.856 | 4854 | A0(?) | 4853.96 | 0.855576 | 0.00310653 | 24.3863
Windverband | -0.076 | +4.311 | 28.51 | 0.004 | 35.077 | 1 | 5674.5 | A0(?) | 5674.5 | 0.999992 | 0.00363168 | 28.5087
Windverband | -0.080 | +3.113 | 24.19 | 0.003 | 35.084 | 0.849 | 4814.4 | A0(?) | 4814.36 | 0.848607 | 0.00308119 | 24.1873
Windverband | -0.076 | +4.258 | 28.29 | 0.004 | 35.077 | 0.992 | 5630.4 | A0(?) | 5630.41 | 0.992231 | 0.00360346 | 28.2872
4 x Windverband | -0.081 | +3.113 | 24.45 | 0.003 | 35.084 | 0.858 | 4867.4 | A0(?) | 4867.44 | 0.857949 | 0.00311516 | 24.454
4 x Windverband | -0.076 | +4.258 | 28.51 | 0.004 | 35.077 | 1 | 5675.9 | A0(?) | 5675.86 | 1.00023 | 0.00363255 | 28.5155
Windverband | -0.080 | +3.113 | 24.22 | 0.003 | 35.084 | 0.85 | 4821.4 | A0(?) | 4821.42 | 0.84985 | 0.00308571 | 24.2228
Windverband | -0.076 | +4.258 | 28.32 | 0.004 | 35.077 | 0.993 | 5636.4 | A0(?) | 5636.44 | 0.993294 | 0.00360732 | 28.3175
2 x Windverband | +3.053 | +5.539 | 17.96 | 0.002 | 35.104 | 0.63 | 3574.3 | A-20(?) | 3574.28 | 0.630353 | 0.00228754 | 17.9572
2 x Windverband | +3.048 | +4.645 | 15.23 | 0.002 | 35.117 | 0.534 | 3029.3 | A-20(?) | 3029.29 | 0.534435 | 0.00193874 | 15.2191
2 x Windverband | +3.053 | +5.539 | 17.93 | 0.002 | 35.104 | 0.629 | 3568.8 | A-20(?) | 3568.84 | 0.629396 | 0.00228406 | 17.9299
Windverband | -0.076 | +3.108 | 20.45 | 0.003 | 35.093 | 0.718 | 4071 | A0(?) | 4071.03 | 0.717782 | 0.00260546 | 20.4529
Windverband | -0.076 | +3.108 | 20.45 | 0.003 | 35.093 | 0.718 | 4070.6 | A0(?) | 4070.65 | 0.717714 | 0.00260521 | 20.4509
2 x Windverband | +3.049 | +5.543 | 21.36 | 0.003 | 35.092 | 0.749 | 4249.5 | A-20(?) | 4249.5 | 0.749192 | 0.00271968 | 21.3495
Windverband | -0.080 | +3.112 | 23.55 | 0.003 | 35.086 | 0.826 | 4688.1 | A0(?) | 4688.06 | 0.826378 | 0.00300036 | 23.5528
Windverband | -0.080 | +3.112 | 23.55 | 0.003 | 35.086 | 0.826 | 4687.7 | A0(?) | 4687.72 | 0.826319 | 0.00300014 | 23.5511
Windverband | -0.076 | +3.108 | 20.5 | 0.003 | 35.093 | 0.72 | 4081.2 | A0(?) | 4081.2 | 0.719572 | 0.00261197 | 20.504
Windverband | -0.076 | +3.108 | 20.5 | 0.003 | 35.093 | 0.72 | 4080.8 | A0(?) | 4080.82 | 0.719504 | 0.00261173 | 20.502
Windverband | -0.079 | +3.014 | 21.78 | 0.003 | 35.09 | 0.764 | 4334.8 | A0(?) | 4334.84 | 0.764212 | 0.0027743 | 21.7782
Windverband | -0.074 | +4.094 | 25.89 | 0.003 | 35.081 | 0.908 | 5152.8 | A0(?) | 5152.76 | 0.908166 | 0.00329777 | 25.8875
Windverband | -0.059 | +2.973 | 25.72 | 0.003 | 35.081 | 0.902 | 5120.4 | A0(?) | 5120.38 | 0.902466 | 0.00327704 | 25.7248
Windverband | -0.059 | +2.973 | 25.72 | 0.003 | 35.081 | 0.902 | 5120.1 | A0(?) | 5120.09 | 0.902415 | 0.00327685 | 25.7233
Windverband | -0.113 | +2.986 | 24.43 | 0.003 | 35.084 | 0.857 | 4863.6 | A0(?) | 4863.57 | 0.857268 | 0.00311268 | 24.4346
Windverband | -0.081 | +3.016 | 24.43 | 0.003 | 35.084 | 0.857 | 4863.3 | A0(?) | 4863.25 | 0.857213 | 0.00311248 | 24.433
Windverband | +2.887 | +5.259 | 17.18 | 0.002 | 35.107 | 0.603 | 3419.7 | A-20(?) | 3419.71 | 0.603149 | 0.00218862 | 17.1806
Windverband | +2.891 | +6.045 | 20.08 | 0.003 | 35.096 | 0.705 | 3996.8 | A-20(?) | 3996.83 | 0.704722 | 0.00255797 | 20.0801
Windverband | -0.076 | +2.874 | 19.3 | 0.002 | 35.098 | 0.677 | 3841.4 | A0(?) | 3841.42 | 0.67737 | 0.00245851 | 19.2993
Windverband | -0.076 | +2.873 | 19.3 | 0.002 | 35.098 | 0.677 | 3841 | A0(?) | 3841.04 | 0.677304 | 0.00245827 | 19.2974
Windverband | -0.084 | +2.934 | 28.53 | 0.004 | 35.077 | 1.001 | 5678.5 | A0(?) | 5678.54 | 1.0007 | 0.00363427 | 28.529
Windverband | -0.086 | +2.934 | 28.53 | 0.004 | 35.077 | 1.001 | 5679.7 | A0(?) | 5679.73 | 1.00091 | 0.00363502 | 28.5349
Windverband | -0.076 | +2.942 | 19.55 | 0.002 | 35.096 | 0.686 | 3891 | A0(?) | 3891.01 | 0.686098 | 0.00249025 | 19.5484
Windverband | -0.076 | +2.942 | 19.55 | 0.002 | 35.096 | 0.686 | 3890.6 | A0(?) | 3890.63 | 0.686031 | 0.00249 | 19.5465

# IfcPlate: PL15*240 (3)
In: Undefined
Description: PL15*240; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: PLAAT
Tekla Common - Bottom elevation: -0.050; Top elevation: -0.035; Phase: 1010; Class: 99
Tekla Quantity - Weight: 6.78 kg; Volume: 0.001 m3; Gross footprint area: 0.058 m2; Area per tons: 19.108 m2; Net surface area: 0.13 m2; Height: 240 mm; Width: 15 mm; Length: 240 mm
Pset_PlateCommon - IsExternal: no; LoadBearing: no; Reference: P0(?)
BaseQuantities - Width: 240 mm; NetArea: 0.1296 m2; GrossArea: 0.1296 m2; CrossSectionArea: 0.0036 m2; NetVolume: 0.000864 m3; GrossVolume: 0.000864 m3

# IfcPlate: STRIP15*140 (4)
In: Undefined
Description: STRIP15*140; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: PLAAT
Pset_PlateCommon - IsExternal: no; LoadBearing: no; Reference: P0(?)
Tekla Common - Phase: 1010; Class: 99
Tekla Quantity - Weight: 2.31 kg; Volume: 0 m3; Gross footprint area: 0.02 m2; Area per tons: 20.625 m2; Net surface area: 0.048 m2; Height: 140 mm; Width: 15 mm; Length: 140 mm
BaseQuantities - Width: 140 mm; NetArea: 0.0476 m2; GrossArea: 0.0476 m2; CrossSectionArea: 0.0021 m2; NetVolume: 0.000294 m3; GrossVolume: 0.000294 m3
Name | Bottom elevation | Top elevation
PLAAT | -0.250 | -0.235
3 x PLAAT | -0.050 | -0.035

# IfcPlate: STRIP15*220 (6)
In: Undefined
Description: STRIP15*220; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: PLAAT
Tekla Common - Phase: 1010; Class: 99
Pset_PlateCommon - IsExternal: no; LoadBearing: no; Reference: P0(?)
Tekla Quantity - Weight: 5.7 kg; Volume: 0.001 m3; Gross footprint area: 0.048 m2; Area per tons: 19.301 m2; Net surface area: 0.11 m2; Height: 220 mm; Width: 15 mm; Length: 220 mm
BaseQuantities - Width: 220 mm; NetArea: 0.11 m2; GrossArea: 0.11 m2; CrossSectionArea: 0.0033 m2; NetVolume: 0.000726 m3; GrossVolume: 0.000726 m3
Name | Bottom elevation | Top elevation
5 x PLAAT | -0.050 | -0.035
PLAAT | -0.070 | -0.055
