Properties of the parts of a building model (IFC2X3), part 1 of 3

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:On], Option [Welds:On], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:On], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: 8694 IFC Staal revC 30-03-2023.ifc
Time: 2023-03-29T16:44:34
Author: IMJ\s.sijsma
Organization: Structural Designer
Written by: IFC Parser Version: 3.13.2
Made in: Tekla Structures 2022 Service Pack 4, IFC Export Version: 4.0.0.0 Aug 24 2022

# IfcProject, Undefined
BIM Basis ILS - IFC_BUILDING_STOREY: Undefined

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: B76.1/4 (2)
In: Undefined
Description: B76.1/4; Material: STEEL/S275JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S275JR; NAME: Koppelkoker
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A-10(?)
Tekla Common - Phase: 1010; Class: 9
Tekla Quantity - Volume: 0.002 m3; Gross footprint area: 0 m2; Area per tons: 33.745 m2; Height: 76.1 mm; Width: 76.1 mm
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Koppelkoker | +2.861 | +2.937 | 14.84 | 0.497 | 2087 | 2087.01 | 0.500882 | 0.00184267 | 14.465
Koppelkoker | +2.863 | +2.939 | 14.27 | 0.478 | 2006.8 | 2006.75 | 0.48162 | 0.00177182 | 13.9088

# IfcBeam: HEA140 (117)
In: Undefined
Description: HEA140; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Phase: 1010; Class: 1
Tekla Quantity - Area per tons: 32.05 m2; Height: 133 mm; Width: 140 mm
Pset_BeamCommon - IsExternal: no; LoadBearing: no
Name | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Ligger | +3.009 | +3.142 | 228.99 | 0.029 | 1.301 | 7.577 | 9289.9 | A0(?) | 9289.95 | 7.33906 | 0.0280371 | 220.091 | Default - comment: tbv LBK
4 x Ligger | +2.919 | +3.052 | 102.74 | 0.013 | 0.584 | 3.403 | 4168.1 | A0(?) | 4168.15 | 3.29284 | 0.0125795 | 98.7488 | Default - comment: tbv LBK
Ligger | +4.219 | +4.352 | 28.35 | 0.004 | 0.161 | 0.943 | 1150 | A0(?) | 1150 | 0.908502 | 0.0034707 | 27.245
Ligger | +3.009 | +3.142 | 82.19 | 0.01 | 0.467 | 2.724 | 3334.5 | A0(?) | 3334.46 | 2.63422 | 0.0100634 | 78.9977
Ligger | +3.009 | +3.142 | 97.81 | 0.012 | 0.556 | 3.24 | 3968 | A0(?) | 3968.02 | 3.13473 | 0.0119755 | 94.0074
Ligger | +4.219 | +4.352 | 51.54 | 0.007 | 0.293 | 1.71 | 2091.1 | A0(?) | 2091.07 | 1.65195 | 0.00631086 | 49.5402
Ligger | +4.219 | +4.352 | 75.63 | 0.01 | 0.43 | 2.507 | 3068.4 | A0(?) | 3068.38 | 2.42402 | 0.00926037 | 72.6939
Ligger | +3.009 | +3.142 | 88.44 | 0.01 | 0.502 | 2.93 | 3588.1 | A0(?) | 3588.07 | 2.83458 | 0.0108288 | 85.006
Ligger | +3.009 | +3.142 | 78.46 | 0.01 | 0.446 | 2.6 | 3183.1 | A0(?) | 3183.1 | 2.51465 | 0.0096066 | 75.4118
Ligger | +3.009 | +3.142 | 70.2 | 0.01 | 0.399 | 2.327 | 2847.9 | A0(?) | 2847.93 | 2.24986 | 0.00859505 | 67.4711
Ligger | +3.009 | +3.142 | 81.32 | 0.01 | 0.462 | 2.695 | 3298.9 | A0(?) | 3298.94 | 2.60616 | 0.00995619 | 78.1561
Ligger | +4.219 | +4.352 | 19.11 | 0.002 | 0.109 | 0.638 | 775.3 | A0(?) | 775.318 | 0.612501 | 0.00233991 | 18.3683
Ligger | +4.219 | +4.352 | 69.21 | 0.01 | 0.393 | 2.294 | 2807.7 | A0(?) | 2807.67 | 2.21806 | 0.00847354 | 66.5173
Ligger | +4.219 | +4.352 | 69.57 | 0.01 | 0.395 | 2.306 | 2822.6 | A0(?) | 2822.57 | 2.22983 | 0.00851852 | 66.8704
Ligger | +4.219 | +4.352 | 196.66 | 0.025 | 1.117 | 6.509 | 7978.6 | A0(?) | 7978.55 | 6.30306 | 0.0240793 | 189.022
Ligger | +3.009 | +3.142 | 112.28 | 0.013 | 0.638 | 3.719 | 4555.2 | A0(?) | 4555.17 | 3.59859 | 0.0137475 | 107.918
Ligger | +3.019 | +3.152 | 59.71 | 0.008 | 0.338 | 1.973 | 2422.6 | A0(?) | 2422.61 | 1.91386 | 0.00728236 | 57.1666
Ligger | +3.019 | +3.152 | 63.51 | 0.008 | 0.361 | 2.106 | 2576.4 | A0(?) | 2576.38 | 2.03534 | 0.00777552 | 61.0378
Ligger | +3.009 | +3.142 | 35.95 | 0.005 | 0.204 | 1.195 | 1458.3 | A0(?) | 1458.3 | 1.15206 | 0.00440116 | 34.5491
Ligger | +3.009 | +3.142 | 35.95 | 0.005 | 0.204 | 1.195 | 1458.5 | A0(?) | 1458.54 | 1.15225 | 0.00440189 | 34.5548
Ligger | +3.009 | +3.142 | 64.7 | 0.008 | 0.367 | 2.145 | 2624.7 | A0(?) | 2624.7 | 2.07351 | 0.00792134 | 62.1825
Ligger | +3.009 | +3.142 | 64.69 | 0.008 | 0.367 | 2.145 | 2624.4 | A0(?) | 2624.4 | 2.07328 | 0.00792044 | 62.1754
Ligger | +3.009 | +3.142 | 64.7 | 0.008 | 0.367 | 2.145 | 2624.7 | A0(?) | 2624.77 | 2.07357 | 0.00792156 | 62.1842
Ligger | +3.009 | +3.142 | 64.63 | 0.008 | 0.367 | 2.143 | 2622 | A0(?) | 2622.02 | 2.0714 | 0.00791327 | 62.1192
Ligger | +3.009 | +3.142 | 43.53 | 0.006 | 0.247 | 1.445 | 1766 | A0(?) | 1765.97 | 1.39512 | 0.0053297 | 41.8381
Ligger | +3.009 | +3.142 | 43.51 | 0.006 | 0.247 | 1.445 | 1765.2 | A0(?) | 1765.16 | 1.39448 | 0.00532725 | 41.8189
Ligger | +3.009 | +3.142 | 64.63 | 0.008 | 0.367 | 2.143 | 2621.5 | A0(?) | 2621.52 | 2.071 | 0.00791175 | 62.1072
Ligger | +3.009 | +3.142 | 78.76 | 0.01 | 0.447 | 2.61 | 3195.3 | A0(?) | 3195.28 | 2.52427 | 0.00964335 | 75.7003
Ligger | +3.009 | +3.142 | 64.79 | 0.008 | 0.368 | 2.148 | 2628.7 | A0(?) | 2628.67 | 2.07665 | 0.00793333 | 62.2766
Ligger | +3.009 | +3.142 | 64.65 | 0.008 | 0.367 | 2.143 | 2622.7 | A0(?) | 2622.69 | 2.07193 | 0.00791529 | 62.135
Ligger | +3.009 | +3.142 | 64.7 | 0.008 | 0.367 | 2.145 | 2624.9 | A0(?) | 2624.86 | 2.07364 | 0.00792183 | 62.1864
Ligger | +3.009 | +3.142 | 64.71 | 0.008 | 0.368 | 2.145 | 2625.4 | A0(?) | 2625.41 | 2.07407 | 0.00792347 | 62.1993
2 x Ligger | +5.937 | +6.070 | 53.08 | 0.007 | 0.301 | 1.762 | 2153.5 | A0(?) | 2153.5 | 1.70127 | 0.00649926 | 51.0192
Ligger | +2.837 | +2.970 | 106.13 | 0.013 | 0.601 | 3.506 | 4305.5 | A-10(?) | 4305.47 | 3.40132 | 0.0129599 | 101.736
Ligger | +2.837 | +2.970 | 104.69 | 0.013 | 0.592 | 3.454 | 4247.1 | A-10(?) | 4247.13 | 3.35523 | 0.0127689 | 100.236
Ligger | +2.837 | +2.970 | 104.67 | 0.013 | 0.592 | 3.454 | 4246.6 | A-10(?) | 4246.6 | 3.35481 | 0.0127688 | 100.235
Ligger | +2.837 | +2.970 | 104.67 | 0.013 | 0.592 | 3.454 | 4246.6 | A-10(?) | 4246.6 | 3.35481 | 0.0127681 | 100.229
Ligger | +2.837 | +2.970 | 104.69 | 0.013 | 0.592 | 3.454 | 4247.3 | A-10(?) | 4247.29 | 3.35536 | 0.0127702 | 100.246
Ligger | +2.837 | +2.970 | 104.67 | 0.013 | 0.592 | 3.454 | 4246.4 | A-10(?) | 4246.35 | 3.35462 | 0.0127673 | 100.224
Ligger | +2.837 | +2.970 | 68.68 | 0.01 | 0.389 | 2.268 | 2786.2 | A-10(?) | 2786.21 | 2.20111 | 0.0083768 | 65.7578
Ligger | +2.837 | +2.970 | 68.68 | 0.01 | 0.389 | 2.268 | 2786.5 | A-10(?) | 2786.55 | 2.20137 | 0.00837798 | 65.7671
Ligger | +6.169 | +6.302 | 66.93 | 0.01 | 0.379 | 2.21 | 2715.3 | A-20(?) | 2715.33 | 2.14511 | 0.00816217 | 64.073
Ligger | +6.169 | +6.302 | 49.26 | 0.006 | 0.278 | 1.622 | 1998.3 | A-20(?) | 1998.35 | 1.57869 | 0.0059826 | 46.9634
Ligger | +6.169 | +6.302 | 50.79 | 0.006 | 0.287 | 1.679 | 2060.7 | A-20(?) | 2060.69 | 1.62795 | 0.00619608 | 48.6392
Ligger | +6.169 | +6.302 | 49.26 | 0.006 | 0.278 | 1.622 | 1998.3 | A-20(?) | 1998.41 | 1.57874 | 0.0059831 | 46.9674
Ligger | +6.169 | +6.302 | 49.26 | 0.006 | 0.278 | 1.622 | 1998.3 | A-20(?) | 1998.4 | 1.57873 | 0.00598301 | 46.9666
Ligger | +6.169 | +6.302 | 49.23 | 0.006 | 0.277 | 1.621 | 1997.1 | A-20(?) | 1997.11 | 1.57772 | 0.00597913 | 46.9361
Ligger | +6.169 | +6.302 | 25.53 | 0.003 | 0.143 | 0.841 | 1035.6 | A-20(?) | 1035.64 | 0.818152 | 0.00309162 | 24.2692
Ligger | +6.169 | +6.302 | 31.63 | 0.004 | 0.178 | 1.043 | 1283.3 | A-20(?) | 1283.26 | 1.01377 | 0.00383972 | 30.1418
Ligger | +6.169 | +6.302 | 31.63 | 0.004 | 0.178 | 1.043 | 1283.3 | A-20(?) | 1283.39 | 1.01388 | 0.00384113 | 30.1528
Ligger | +2.782 | +6.250 | 262.5 | 0.033 | 0 | 8.65 | 10649.5 | A-20(?) | 10649.5 | 8.41308 | 0.0320074 | 251.258
Ligger | +2.837 | +2.970 | 104.69 | 0.013 | 0.592 | 3.454 | 4247.1 | A-10(?) | 4247.05 | 3.35517 | 0.0127694 | 100.24
Ligger | +2.837 | +2.970 | 96.87 | 0.012 | 0.55 | 3.209 | 3930.2 | A-10(?) | 3930.17 | 3.10484 | 0.0118613 | 93.1109
Ligger | +2.837 | +2.970 | 82.53 | 0.01 | 0.469 | 2.735 | 3348.2 | A-10(?) | 3348.16 | 2.64505 | 0.0101048 | 79.3223
Ligger | +2.837 | +2.970 | 104.69 | 0.013 | 0.593 | 3.458 | 4246.6 | A-10(?) | 4246.7 | 3.35489 | 0.0127826 | 100.343
Ligger | +2.837 | +2.970 | 104.69 | 0.013 | 0.592 | 3.454 | 4246.9 | A-10(?) | 4246.92 | 3.35507 | 0.012769 | 100.237
Ligger | +2.837 | +2.970 | 104.69 | 0.013 | 0.592 | 3.454 | 4246.6 | A-10(?) | 4246.62 | 3.35483 | 0.0127682 | 100.23
Ligger | +2.837 | +2.970 | 104.69 | 0.013 | 0.592 | 3.454 | 4246.9 | A-10(?) | 4246.99 | 3.35512 | 0.0127693 | 100.239
Ligger | +2.837 | +2.970 | 104.69 | 0.013 | 0.592 | 3.454 | 4246.6 | A-10(?) | 4246.68 | 3.35488 | 0.0127683 | 100.231
Ligger | +6.169 | +6.302 | 25.5 | 0.003 | 0.143 | 0.841 | 1034.7 | A-20(?) | 1034.71 | 0.817421 | 0.00309138 | 24.2673
Ligger | +6.169 | +6.302 | 49.22 | 0.006 | 0.277 | 1.621 | 1997 | A-20(?) | 1997.03 | 1.57766 | 0.00597925 | 46.9371
Ligger | +6.169 | +6.302 | 49.26 | 0.006 | 0.278 | 1.622 | 1998.3 | A-20(?) | 1998.33 | 1.57868 | 0.00598253 | 46.9629
Ligger | +6.169 | +6.302 | 49.26 | 0.006 | 0.278 | 1.622 | 1998.2 | A-20(?) | 1998.22 | 1.57859 | 0.00598241 | 46.9619
Ligger | +6.169 | +6.302 | 49.26 | 0.006 | 0.278 | 1.622 | 1998.2 | A-20(?) | 1998.23 | 1.5786 | 0.00598251 | 46.9627
Ligger | +4.219 | +4.352 | 21.17 | 0.003 | 0.12 | 0.706 | 858.7 | A0(?) | 858.712 | 0.678382 | 0.00259159 | 20.344
Ligger | +4.219 | +4.352 | 95.7 | 0.012 | 0.544 | 3.17 | 3882.5 | A0(?) | 3882.51 | 3.06719 | 0.0117174 | 91.9818
Ligger | +4.219 | +4.352 | 82.52 | 0.01 | 0.469 | 2.735 | 3347.6 | A0(?) | 3347.64 | 2.64464 | 0.0101032 | 79.3101
Ligger | +6.169 | +6.302 | 82.52 | 0.01 | 0.469 | 2.735 | 3347.6 | A-20(?) | 3347.64 | 2.64464 | 0.0101032 | 79.3101
Ligger | +6.169 | +6.302 | 96.79 | 0.012 | 0.55 | 3.206 | 3926.7 | A-20(?) | 3926.69 | 3.10208 | 0.0118507 | 93.0284
Ligger | +4.219 | +4.352 | 22.92 | 0.003 | 0.13 | 0.764 | 929.8 | A0(?) | 929.844 | 0.734576 | 0.00280626 | 22.0292
Ligger | +3.009 | +3.142 | 77.07 | 0.01 | 0.438 | 2.554 | 3126.8 | A0(?) | 3126.81 | 2.47018 | 0.00943671 | 74.0782
Ligger | +3.009 | +3.142 | 64.69 | 0.008 | 0.367 | 2.145 | 2624.4 | A0(?) | 2624.29 | 2.07319 | 0.00792012 | 62.1729
Ligger | +6.169 | +6.302 | 65.45 | 0.008 | 0.37 | 2.161 | 2655.5 | A-20(?) | 2655.46 | 2.09781 | 0.00798016 | 62.6443
Ligger | +6.169 | +6.302 | 49.26 | 0.006 | 0.278 | 1.622 | 1998.3 | A-20(?) | 1998.38 | 1.57872 | 0.00598291 | 46.9658
Ligger | +3.009 | +3.142 | 114.55 | 0.015 | 0.651 | 3.793 | 4647.2 | A0(?) | 4647.18 | 3.67127 | 0.0140252 | 110.098
Ligger | +3.009 | +3.142 | 114.92 | 0.015 | 0.653 | 3.806 | 4662.3 | A0(?) | 4662.33 | 3.68324 | 0.0140709 | 110.457
Ligger | +3.009 | +3.142 | 82.52 | 0.01 | 0.469 | 2.735 | 3347.6 | A0(?) | 3347.64 | 2.64464 | 0.0101032 | 79.3101
Ligger | +3.009 | +3.142 | 96.48 | 0.012 | 0.548 | 3.196 | 3914 | A0(?) | 3913.99 | 3.09205 | 0.0118124 | 92.7275
Ligger | +3.009 | +3.142 | 149.94 | 0.018 | 0.852 | 4.964 | 6083 | A0(?) | 6083 | 4.80557 | 0.0183585 | 144.114
Ligger | +5.937 | +6.070 | 98.63 | 0.013 | 0.56 | 3.267 | 4001.3 | A0(?) | 4001.3 | 3.16102 | 0.0120759 | 94.7959
Ligger | +5.937 | +6.070 | 123.61 | 0.016 | 0.702 | 4.093 | 5015 | A0(?) | 5015 | 3.96185 | 0.0151353 | 118.812
Ligger | +5.937 | +6.070 | 98.37 | 0.013 | 0.559 | 3.259 | 3991 | A0(?) | 3991 | 3.15289 | 0.0120448 | 94.5519
Ligger | +5.937 | +6.070 | 124.07 | 0.016 | 0.705 | 4.108 | 5033.3 | A0(?) | 5033.34 | 3.97634 | 0.0151906 | 119.246
2 x Ligger | +6.163 | +6.296 | 53.08 | 0.007 | 0.301 | 1.762 | 2153.5 | A-20(?) | 2153.5 | 1.70127 | 0.00649926 | 51.0192
2 x Ligger | +5.999 | +6.169 | 52.64 | 0.007 | 0 | 1.746 | 2135.4 | A-20(?) | 2135.43 | 1.68699 | 0.00644473 | 50.5911 | Default - comment: Momentvast
2 x Ligger | +4.471 | +4.640 | 52.64 | 0.007 | 0 | 1.746 | 2135.4 | A-20(?) | 2135.43 | 1.68699 | 0.00644473 | 50.5911
Ligger | +2.825 | +6.078 | 249.42 | 0.032 | 0 | 8.218 | 10118.9 | A-20(?) | 10118.9 | 7.99391 | 0.0304084 | 238.706
Ligger | +2.825 | +6.078 | 249.4 | 0.032 | 0 | 8.218 | 10118.2 | A-20(?) | 10118.2 | 7.99334 | 0.0304062 | 238.689
Ligger | +2.841 | +2.974 | 41.74 | 0.005 | 0.237 | 1.386 | 1693.5 | A0(?) | 1693.47 | 1.33784 | 0.00511089 | 40.1205
Ligger | +2.834 | +2.974 | 98.74 | 0.013 | 0.068 | 3.271 | 4006 | A0(?) | 4006 | 3.16474 | 0.0120901 | 94.9074
2 x Ligger | +2.842 | +2.975 | 111.59 | 0.013 | 0.634 | 3.696 | 4527.1 | A-20(?) | 4527.1 | 3.57641 | 0.0136628 | 107.253
Ligger | +5.900 | +6.033 | 228.19 | 0.029 | 1.296 | 7.551 | 9257.6 | A-20(?) | 9257.59 | 7.3135 | 0.0279394 | 219.324
Ligger | +2.834 | +2.974 | 100.97 | 0.013 | 0.07 | 3.345 | 4096.3 | A0(?) | 4096.29 | 3.23607 | 0.0123626 | 97.0464
Ligger | +2.841 | +2.974 | 41.81 | 0.005 | 0.237 | 1.389 | 1696.3 | A0(?) | 1696.29 | 1.34007 | 0.0051194 | 40.1873
Ligger | +2.822 | +2.955 | 165.83 | 0.021 | 0.942 | 5.489 | 6727.7 | A0(?) | 6727.7 | 5.31488 | 0.0203042 | 159.388
Ligger | +6.163 | +6.296 | 100.01 | 0.013 | 0.568 | 3.313 | 4057.3 | A-20(?) | 4057.3 | 3.20527 | 0.0122449 | 96.1227
Ligger | +6.163 | +6.296 | 116.9 | 0.015 | 0.664 | 3.871 | 4742.8 | A-20(?) | 4742.75 | 3.74677 | 0.0143136 | 112.362
Ligger | +6.163 | +6.296 | 80.72 | 0.01 | 0.458 | 2.675 | 3274.8 | A-20(?) | 3274.84 | 2.58712 | 0.00988347 | 77.5852
Ligger | +6.163 | +6.296 | 94.18 | 0.012 | 0.535 | 3.12 | 3820.7 | A-20(?) | 3820.73 | 3.01837 | 0.0115309 | 90.5179
Ligger | +2.826 | +6.260 | 263.85 | 0.034 | 0 | 8.695 | 10704.2 | A-20(?) | 10704.2 | 8.45633 | 0.0321749 | 252.573
Ligger | +2.822 | +2.955 | 73.35 | 0.01 | 0.417 | 2.431 | 2975.7 | A0(?) | 2975.71 | 2.35081 | 0.00898066 | 70.4982
Ligger | +2.822 | +2.955 | 94.18 | 0.012 | 0.535 | 3.12 | 3821.1 | A0(?) | 3821.05 | 3.01863 | 0.0115319 | 90.5256
Ligger | +2.813 | +2.946 | 58.76 | 0.007 | 0.334 | 1.949 | 2384 | A0(?) | 2383.95 | 1.88332 | 0.00719477 | 56.4789
Ligger | +2.822 | +2.955 | 58.52 | 0.007 | 0.332 | 1.941 | 2374.3 | A0(?) | 2374.31 | 1.87571 | 0.00716567 | 56.2505
Ligger | +2.837 | +2.970 | 97.73 | 0.012 | 0.555 | 3.237 | 3964.7 | A-10(?) | 3964.7 | 3.13211 | 0.0119655 | 93.9289
Ligger | +2.836 | +2.969 | 73.29 | 0.01 | 0.417 | 2.429 | 2973.4 | A-10(?) | 2973.43 | 2.34901 | 0.00897383 | 70.4445
Ligger | +2.836 | +2.969 | 97.61 | 0.012 | 0.554 | 3.233 | 3959.8 | A-10(?) | 3959.8 | 3.12824 | 0.0119507 | 93.8128
Ligger | +2.836 | +2.969 | 116 | 0.015 | 0.659 | 3.842 | 4706.2 | A-10(?) | 4706.15 | 3.71786 | 0.0142032 | 111.495

# IfcBeam: HEA160 (12)
In: Undefined
Description: HEA160; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Phase: 1010; Class: 3
Tekla Quantity - Area per tons: 29.885 m2; Height: 152 mm; Width: 160 mm
Name | Reference | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | A0(?) | +2.822 | +2.974 | 121.74 | 0.016 | 0.64 | 3.734 | 3998.1 | 3998.1 | 3.63827 | 0.014729 | 115.623
Ligger | A0(?) | +2.822 | +2.974 | 121.88 | 0.016 | 0.64 | 3.738 | 4002.8 | 4002.76 | 3.64251 | 0.0147462 | 115.757
Ligger | A0(?) | +2.813 | +2.974 | 290.36 | 0.036 | 0 | 8.894 | 9535.5 | 9535.46 | 8.67727 | 0.0351283 | 275.757
Ligger | A0(?) | +2.822 | +2.974 | 79.71 | 0.01 | 0.419 | 2.447 | 2617.7 | 2617.74 | 2.38214 | 0.00964375 | 75.7035
Ligger | A0(?) | +2.822 | +2.974 | 204.86 | 0.027 | 1.076 | 6.278 | 6727.7 | 6727.7 | 6.12221 | 0.0247849 | 194.561
Ligger | A0(?) | +2.822 | +2.974 | 147.38 | 0.018 | 0.774 | 4.518 | 4840.2 | 4840.2 | 4.40458 | 0.0178313 | 139.975
Ligger | A0(?) | +2.822 | +2.974 | 30.93 | 0.004 | 0.163 | 0.954 | 1015.7 | 1015.65 | 0.924243 | 0.00374166 | 29.372
Ligger | A0(?) | +2.822 | +2.974 | 121.26 | 0.015 | 0.637 | 3.719 | 3982.1 | 3982.1 | 3.62371 | 0.0146701 | 115.16
Ligger | A0(?) | +2.822 | +2.974 | 116.57 | 0.015 | 0.613 | 3.575 | 3828.2 | 3828.2 | 3.48366 | 0.0141031 | 110.709
Ligger | A0(?) | +2.822 | +2.974 | 143.1 | 0.018 | 0.752 | 4.387 | 4699.5 | 4699.45 | 4.2765 | 0.0173128 | 135.905
Ligger | A0(?) | +2.822 | +2.974 | 90.92 | 0.012 | 0.478 | 2.79 | 2986 | 2985.98 | 2.71725 | 0.0110004 | 86.3529
Ligger | A-10(?) | +2.816 | +3.010 | 295.41 | 0.038 | 0 | 9.049 | 9701.3 | 9701.28 | 8.82817 | 0.0357395 | 280.555

# IfcBeam: HEA180 (4)
In: Undefined
Description: HEA180; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Bottom elevation: +2.803; Top elevation: +2.974; Phase: 1010; Class: 3
Tekla Quantity - Area per tons: 28.684 m2; Height: 171 mm; Width: 180 mm
Name | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | 327.98 | 0.042 | 1.66 | 9.693 | 9223.1 | 9223.1 | 9.40756 | 0.0399545 | 313.643
Ligger | 62.68 | 0.008 | 0.317 | 1.86 | 1762.7 | 1762.73 | 1.79798 | 0.00763613 | 59.9436
Ligger | 110.66 | 0.013 | 0.56 | 3.276 | 3112 | 3111.97 | 3.17421 | 0.0134811 | 105.826
Ligger | 143.24 | 0.018 | 0.725 | 4.238 | 4028.1 | 4028.1 | 4.10866 | 0.0174497 | 136.98

# IfcBeam: HEA220 (2)
In: Undefined
Description: HEA220; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Bottom elevation: +2.916; Top elevation: +3.142; Phase: 1010; Class: 6
Tekla Quantity - Weight: 165.38 kg; Volume: 0.021 m3; Gross footprint area: 0 m2; Area per tons: 24.963 m2; Net surface area: 4.226 m2; Height: 210 mm; Width: 220 mm; Length: 3276.5 mm
BaseQuantities - Length: 3276.49 mm; OuterSurfaceArea: 4.12838 m2; NetVolume: 0.0201701 m3; NetWeight: 158.335 kg

# IfcBeam: HEA240 (3)
In: Undefined
Description: HEA240; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Bottom elevation: +2.912; Top elevation: +3.142; Phase: 1010; Class: 10
Tekla Quantity - Area per tons: 22.724 m2; Height: 230 mm; Width: 240 mm
Name | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | 1317.74 | 0.168 | 5.222 | 30.587 | 21857.5 | 21857.5 | 29.9447 | 0.15895 | 1247.76
Ligger | 280.28 | 0.036 | 1.106 | 6.491 | 4649 | 4649.05 | 6.3692 | 0.0336733 | 264.336
Ligger | 281.06 | 0.036 | 1.109 | 6.505 | 4661.9 | 4661.9 | 6.3868 | 0.0337448 | 264.896

# IfcBeam: HEB160 (6)
In: Undefined
Description: HEB160; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Bottom elevation: +4.192; Top elevation: +4.352; Phase: 1010; Class: 14
Tekla Quantity - Area per tons: 21.583 m2; Height: 160 mm; Width: 160 mm
Name | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | 127.58 | 0.016 | 0.479 | 2.836 | 2992.9 | 2992.95 | 2.75351 | 0.0156591 | 122.924
Ligger | 142.69 | 0.018 | 0.536 | 3.171 | 3347.6 | 3347.6 | 3.07979 | 0.0175146 | 137.49
Ligger | 120.53 | 0.015 | 0.452 | 2.68 | 2827.7 | 2827.72 | 2.60151 | 0.0147946 | 116.138
Ligger | 108.42 | 0.013 | 0.407 | 2.412 | 2543.5 | 2543.54 | 2.34006 | 0.0133078 | 104.466
Ligger | 138.55 | 0.018 | 0.52 | 3.079 | 3250.5 | 3250.38 | 2.99035 | 0.017006 | 133.497
Ligger | 136.21 | 0.017 | 0.511 | 3.027 | 3195.3 | 3195.39 | 2.93976 | 0.0167183 | 131.239

# IfcBeam: HEB220 (4)
In: Undefined
Description: HEB220; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Bottom elevation: +2.922; Top elevation: +3.142; Phase: 1010; Class: 14
Tekla Quantity - Area per tons: 17.778 m2; Height: 220 mm; Width: 220 mm
Name | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | 403.75 | 0.051 | 1.222 | 7.246 | 5651.9 | 5651.94 | 7.17796 | 0.0490153 | 384.77
Ligger | 446.23 | 0.057 | 1.361 | 8.067 | 6246.7 | 6246.68 | 7.93329 | 0.054599 | 428.602
Ligger | 446.02 | 0.057 | 1.361 | 8.063 | 6243.7 | 6243.73 | 7.92954 | 0.0545733 | 428.4
Ligger | 403.68 | 0.051 | 1.222 | 7.245 | 5651 | 5651.03 | 7.17681 | 0.0490076 | 384.71

# IfcBeam: HEB240 (3)
In: Undefined
Description: HEB240; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Bottom elevation: +2.902; Top elevation: +3.142; Phase: 1010; Class: 13
Tekla Quantity - Area per tons: 16.585 m2; Height: 240 mm; Width: 240 mm
Name | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | 588.29 | 0.075 | 1.689 | 10.012 | 7069.9 | 7069.9 | 9.75647 | 0.0719069 | 564.469
Ligger | 588.52 | 0.075 | 1.689 | 10.016 | 7072.7 | 7072.75 | 9.76039 | 0.0719356 | 564.695
Ligger | 600.61 | 0.077 | 1.732 | 10.27 | 7218 | 7217.95 | 9.96077 | 0.0737675 | 579.075

# IfcBeam: IPE200 (5)
In: Undefined
Description: IPE200; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Bottom elevation: +2.852; Top elevation: +3.052; Phase: 1010; Class: 10
Tekla Quantity - Area per tons: 34.417 m2; Height: 200 mm; Width: 100 mm
Name | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | 187.54 | 0.024 | 0.838 | 6.618 | 8382.8 | 8382.75 | 6.45472 | 0.0228413 | 179.304
Ligger | 187.23 | 0.024 | 0.837 | 6.607 | 8368.7 | 8368.65 | 6.44386 | 0.0228029 | 179.003
Ligger | 42.7 | 0.005 | 0.191 | 1.511 | 1908.5 | 1908.55 | 1.46958 | 0.00520041 | 40.8233
Ligger | 98.17 | 0.013 | 0.439 | 3.467 | 4388.1 | 4388.15 | 3.37887 | 0.0119568 | 93.861
Ligger | 284.59 | 0.036 | 1.272 | 10.04 | 12720.7 | 12720.7 | 9.79494 | 0.0346614 | 272.092

# IfcBeam: IPE220 (40)
In: Undefined
Description: IPE220; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Phase: 1010; Class: 5
Tekla Quantity - Area per tons: 32.419 m2; Height: 220 mm; Width: 110 mm
Pset_BeamCommon - IsExternal: no; LoadBearing: no
Name | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | +5.357 | +6.345 | 65.94 | 0.008 | 0 | 2.159 | 2514.8 | A-20(?) | 2514.83 | 2.13761 | 0.00796532 | 62.5277
Ligger | +5.470 | +6.342 | 56.11 | 0.007 | 0 | 1.802 | 2140 | A-20(?) | 2140.03 | 1.81902 | 0.00664564 | 52.1683
Ligger | +5.470 | +6.342 | 56.04 | 0.007 | 0 | 1.8 | 2137.2 | A-20(?) | 2137.23 | 1.81665 | 0.00663653 | 52.0967
2 x Ligger | +2.922 | +3.142 | 53.71 | 0.007 | 0.225 | 1.785 | 2048.5 | A0(?) | 2048.49 | 1.74122 | 0.00658271 | 51.6743
2 x Ligger | +2.922 | +3.142 | 209.77 | 0.027 | 0.88 | 6.953 | 8000.6 | A0(?) | 8000.55 | 6.80047 | 0.0257093 | 201.818
Ligger | +2.922 | +3.142 | 85.23 | 0.01 | 0.358 | 2.829 | 3250.5 | A0(?) | 3250.55 | 2.76296 | 0.0104454 | 81.9967
Ligger | +2.922 | +3.142 | 53.01 | 0.007 | 0.222 | 1.762 | 2021.7 | A0(?) | 2021.7 | 1.71844 | 0.00649661 | 50.9984
Ligger | +2.922 | +3.142 | 112.49 | 0.013 | 0.472 | 3.731 | 4290.4 | A0(?) | 4290.41 | 3.64685 | 0.013787 | 108.228
Ligger | +2.922 | +3.142 | 35.69 | 0.005 | 0.15 | 1.188 | 1361 | A0(?) | 1361.04 | 1.15689 | 0.00437363 | 34.333
Ligger | +2.922 | +3.142 | 94.94 | 0.012 | 0.398 | 3.15 | 3621.1 | A0(?) | 3621.11 | 3.07794 | 0.0116362 | 91.3443
Ligger | +2.922 | +3.142 | 72.11 | 0.01 | 0.303 | 2.394 | 2750.2 | A0(?) | 2750.22 | 2.33769 | 0.00883768 | 69.3758
Ligger | +2.922 | +3.142 | 56.04 | 0.007 | 0.235 | 1.862 | 2136.8 | A0(?) | 2136.83 | 1.8163 | 0.00686656 | 53.9025
Ligger | +2.932 | +3.152 | 57.2 | 0.007 | 0.24 | 1.9 | 2181.7 | A0(?) | 2181.7 | 1.85445 | 0.00700889 | 55.0198
Ligger | +5.352 | +6.371 | 68.64 | 0.01 | 0 | 2.218 | 2618.1 | A-20(?) | 2618.12 | 2.2254 | 0.00818327 | 64.2387
Ligger | +5.368 | +6.343 | 64.97 | 0.008 | 0 | 2.096 | 2477.8 | A-20(?) | 2477.82 | 2.10614 | 0.00773255 | 60.7005
Ligger | +5.329 | +6.301 | 64.97 | 0.008 | 0 | 2.096 | 2477.8 | A-20(?) | 2477.83 | 2.10615 | 0.00773366 | 60.7092
Ligger | +5.364 | +6.376 | 68.65 | 0.01 | 0 | 2.218 | 2618.5 | A-20(?) | 2618.5 | 2.22572 | 0.00818575 | 64.2582
Ligger | +5.369 | +6.348 | 64.95 | 0.008 | 0 | 2.096 | 2477.1 | A-20(?) | 2477.14 | 2.10557 | 0.00772803 | 60.665
Ligger | +5.436 | +6.344 | 58.88 | 0.008 | 0 | 1.894 | 2245.9 | A-20(?) | 2245.89 | 1.90901 | 0.00698422 | 54.8261
Ligger | +5.378 | +6.342 | 64.53 | 0.008 | 0 | 2.082 | 2461.1 | A-20(?) | 2461.1 | 2.09194 | 0.00768019 | 60.2895
Ligger | +5.470 | +6.342 | 56.05 | 0.007 | 0 | 1.8 | 2137.6 | A-20(?) | 2137.59 | 1.81695 | 0.00663807 | 52.1089
Ligger | +5.471 | +6.343 | 56.02 | 0.007 | 0 | 1.8 | 2136.8 | A-20(?) | 2136.69 | 1.81619 | 0.00663563 | 52.0897
Ligger | +5.357 | +6.345 | 65.94 | 0.008 | 0 | 2.159 | 2515.1 | A-20(?) | 2515.06 | 2.1378 | 0.00796664 | 62.5381
Ligger | +5.357 | +6.345 | 65.95 | 0.008 | 0 | 2.159 | 2515.1 | A-20(?) | 2515.25 | 2.13796 | 0.00796716 | 62.5422
Ligger | +5.412 | +6.344 | 61.18 | 0.008 | 0 | 2.001 | 2333.4 | A-20(?) | 2333.43 | 1.98341 | 0.00738307 | 57.9571
Ligger | +2.922 | +3.142 | 59.57 | 0.008 | 0.25 | 1.979 | 2272.2 | A0(?) | 2272.21 | 1.93138 | 0.0073016 | 57.3176
2 x Ligger | +2.831 | +6.345 | 280.43 | 0.036 | 0 | 9.231 | 10695.8 | A-20(?) | 10695.8 | 9.09142 | 0.0341406 | 268.004
3 x Ligger | +4.531 | +6.426 | 151.01 | 0.018 | 0 | 4.847 | 5759.5 | A-20(?) | 5759.52 | 4.89559 | 0.0179065 | 140.566
Ligger | +4.533 | +6.426 | 150.82 | 0.018 | 0 | 4.841 | 5752.4 | A-20(?) | 5752.4 | 4.88954 | 0.0178836 | 140.386
Ligger | +2.890 | +6.343 | 275.21 | 0.035 | 0 | 9.058 | 10496.5 | A-20(?) | 10496.5 | 8.92206 | 0.0335003 | 262.978
Ligger | +2.895 | +6.346 | 275.11 | 0.035 | 0 | 9.055 | 10492.9 | A-20(?) | 10492.9 | 8.91893 | 0.0334885 | 262.885
Ligger | +2.839 | +6.343 | 279.53 | 0.036 | 0 | 9.231 | 10661.3 | A-20(?) | 10661.3 | 9.06213 | 0.0341447 | 268.036
Ligger | +2.833 | +6.355 | 281.2 | 0.036 | 0 | 9.256 | 10725 | A-20(?) | 10725 | 9.11622 | 0.0342344 | 268.74
Ligger | +2.868 | +6.351 | 277.75 | 0.035 | 0 | 9.173 | 10593.5 | A-20(?) | 10593.5 | 9.00445 | 0.0339267 | 266.324
Ligger | +2.828 | +6.351 | 281.2 | 0.036 | 0 | 9.256 | 10725.4 | A-20(?) | 10725.4 | 9.11662 | 0.0342358 | 268.751

# IfcBeam: IPE240, Ligger
In: Undefined
Description: IPE240; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: Ligger
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A-20(?)
Tekla Common - Bottom elevation: +2.826; Top elevation: +6.372; Phase: 1010; Class: 6
Tekla Quantity - Weight: 329.42 kg; Volume: 0.042 m3; Gross footprint area: 0 m2; Area per tons: 29.981 m2; Net surface area: 10.107 m2; Height: 240 mm; Width: 120 mm; Length: 10735.3 mm
BaseQuantities - Length: 10735.3 mm; OuterSurfaceArea: 9.87652 m2; NetVolume: 0.0396292 m3; NetWeight: 311.089 kg

# IfcBeam: IPE270 (19)
In: Undefined
Description: IPE270
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - NAME: Ligger
Pset_BeamCommon - IsExternal: no; LoadBearing: no
Tekla Common - Phase: 1010
Tekla Quantity - Area per tons: 28.864 m2; Height: 270 mm; Width: 135 mm
Name | Material | MATERIAL | Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.834 | +5.656 | 6 | 298.3 | 0.038 | 0 | 8.747 | 8278.9 | 8278.86 | 8.61002 | 0.0360486 | 282.981
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.830 | +5.754 | 6 | 310.08 | 0.04 | 0 | 9.096 | 8605.8 | 8605.8 | 8.95004 | 0.0374896 | 294.293
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.830 | +5.754 | 6 | 310.22 | 0.04 | 0 | 9.1 | 8609.6 | 8609.59 | 8.95397 | 0.0375064 | 294.425
Ligger | STEEL/S355JR | S355JR | A0(?) | +2.872 | +3.142 | 2 | 208.63 | 0.027 | 0.782 | 6.186 | 5790.2 | 5790.25 | 6.02186 | 0.025485 | 200.057
Ligger | STEEL/S355JR | S355JR | A0(?) | +2.872 | +3.142 | 2 | 119.88 | 0.015 | 0.449 | 3.558 | 3327 | 3327 | 3.46008 | 0.0146433 | 114.95
Ligger | STEEL/S355JR | S355JR | A0(?) | +2.872 | +3.142 | 2 | 119.79 | 0.015 | 0.449 | 3.555 | 3324.5 | 3324.5 | 3.45748 | 0.0146323 | 114.864
Ligger | STEEL/S355JR | S355JR | A0(?) | +2.872 | +3.142 | 2 | 208.64 | 0.027 | 0.782 | 6.186 | 5790.5 | 5790.54 | 6.02216 | 0.0254862 | 200.067
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.836 | +5.636 | 6 | 296.39 | 0.038 | 0 | 8.691 | 8225.9 | 8225.95 | 8.55499 | 0.0358184 | 281.175
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.837 | +5.652 | 6 | 298.22 | 0.038 | 0 | 8.745 | 8276.5 | 8276.53 | 8.60759 | 0.0360409 | 282.921
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.821 | +5.653 | 6 | 298.5 | 0.038 | 0 | 8.753 | 8284.5 | 8284.47 | 8.61585 | 0.0360741 | 283.181
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.871 | +5.648 | 6 | 296.1 | 0.038 | 0 | 8.683 | 8217.8 | 8217.85 | 8.54656 | 0.0357867 | 280.926
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.809 | +5.613 | 6 | 298.1 | 0.038 | 0 | 8.742 | 8273.2 | 8273.19 | 8.60412 | 0.0360288 | 282.826
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.872 | +5.661 | 6 | 297.89 | 0.038 | 0 | 8.736 | 8267.5 | 8267.48 | 8.59818 | 0.0360057 | 282.645
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.814 | +5.720 | 6 | 306.52 | 0.039 | 0 | 8.987 | 8507 | 8506.98 | 8.84726 | 0.0370403 | 290.767
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.830 | +5.754 | 6 | 310.19 | 0.04 | 0 | 9.1 | 8608.8 | 8608.82 | 8.95317 | 0.037503 | 294.399
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.834 | +5.657 | 6 | 298.44 | 0.038 | 0 | 8.751 | 8282.7 | 8282.67 | 8.61398 | 0.0360674 | 283.129
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.830 | +5.755 | 6 | 310.29 | 0.04 | 0 | 9.102 | 8611.6 | 8611.57 | 8.95603 | 0.0375149 | 294.492
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.834 | +5.658 | 6 | 298.44 | 0.038 | 0 | 8.753 | 8283.2 | 8283.16 | 8.61449 | 0.0360696 | 283.146
Ligger | STEEL/S235JR | S235JR | A-20(?) | +2.831 | +5.715 | 6 | 305.42 | 0.039 | 0 | 8.958 | 8476.5 | 8476.47 | 8.81553 | 0.0369203 | 289.824

# IfcBeam: IPE300 (5)
In: Undefined
Description: IPE300; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: Ligger
Pset_BeamCommon - IsExternal: no; LoadBearing: no
Tekla Common - Phase: 1010
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 27.467 m2; Height: 300 mm; Width: 150 mm
Name | Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | A-20(?) | +2.793 | +6.172 | 2 | 422.85 | 0.054 | 11.825 | 10012.3 | 10012.3 | 11.6142 | 0.0516915 | 405.778
Ligger | A0(?) | +5.767 | +6.154 | 4 | 525.03 | 0.067 | 14.752 | 12431.8 | 12431.8 | 14.4209 | 0.0644969 | 506.3
Ligger | A-30(?) | +5.788 | +6.154 | 2 | 415.78 | 0.053 | 11.685 | 9845 | 9845.01 | 11.4202 | 0.0510765 | 400.951
Ligger | A-20(?) | +3.753 | +4.085 | 2 | 414.85 | 0.053 | 11.658 | 9822.8 | 9822.8 | 11.3945 | 0.0509613 | 400.046
Ligger | A-20(?) | +4.863 | +5.195 | 2 | 414.85 | 0.053 | 11.658 | 9822.8 | 9822.8 | 11.3945 | 0.0509613 | 400.046

# IfcBeam: IPE330 (6)
In: Undefined
Description: IPE330; Material: STEEL/S355JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S355JR; NAME: Ligger
Tekla Common - Bottom elevation: +4.022; Top elevation: +4.352; Phase: 1010; Class: 14
Tekla Quantity - Area per tons: 25.437 m2; Height: 330 mm; Width: 160 mm
Name | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | 321.31 | 0.041 | 1.046 | 8.414 | 6538.5 | 6538.48 | 8.1731 | 0.0391164 | 307.064
Ligger | 459.63 | 0.059 | 1.497 | 12.031 | 9353.4 | 9353.35 | 11.6917 | 0.0559564 | 439.258
Ligger | 460.38 | 0.059 | 1.499 | 12.05 | 9368.5 | 9368.46 | 11.7106 | 0.0560468 | 439.967
Ligger | 447.64 | 0.057 | 1.457 | 11.718 | 9109.4 | 9109.37 | 11.3867 | 0.0544968 | 427.8
Ligger | 455.47 | 0.058 | 1.483 | 11.922 | 9268.6 | 9268.55 | 11.5857 | 0.0554491 | 435.276
Ligger | 460.38 | 0.059 | 1.499 | 12.05 | 9368.5 | 9368.45 | 11.7106 | 0.0560468 | 439.967

# IfcBeam: IPE360, Ligger
In: Undefined
Description: IPE360; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Bottom elevation: +5.707; Top elevation: +6.154; Phase: 1010; Class: 4
Tekla Quantity - Weight: 709.43 kg; Volume: 0.09 m3; Gross footprint area: 0 m2; Area per tons: 23.655 m2; Net surface area: 17.218 m2; Height: 360 mm; Width: 170 mm; Length: 12431 mm
BaseQuantities - Length: 12431 mm; OuterSurfaceArea: 16.7818 m2; NetVolume: 0.0869521 m3; NetWeight: 682.574 kg

# IfcBeam: K100/4, Kokerpligger
In: Undefined
Description: K100/4; Material: STEEL/S275JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S275JR; NAME: Kokerpligger
Tekla Common - Bottom elevation: +0.628; Top elevation: +2.860; Phase: 1010; Class: 990
Tekla Quantity - Weight: 83.12 kg; Volume: 0.01 m3; Gross footprint area: 0 m2; Area per tons: 32.472 m2; Net surface area: 2.77 m2; Height: 100 mm; Width: 100 mm; Length: 6920.5 mm
BaseQuantities - Length: 6920.47 mm; OuterSurfaceArea: 2.69898 m2; NetVolume: 0.0106298 m3; NetWeight: 83.4442 kg

# IfcBeam: K100/5 (2)
In: Undefined
Description: K100/5; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A-10(?)
Default - MATERIAL: S235JR; comment: Momentvast met kopplaten van min. 20mm dik; NAME: Ligger
Tekla Common - Bottom elevation: +3.053; Top elevation: +3.153; Phase: 1010; Class: 1
Tekla Quantity - Weight: 33.75 kg; Volume: 0.004 m3; Gross footprint area: 0.227 m2; Area per tons: 26.287 m2; Net surface area: 0.909 m2; Height: 100 mm; Width: 100 mm
Name | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | 2274.8 | 2274.83 | 0.887184 | 0.00431033 | 33.8361
Ligger | 2274.6 | 2274.56 | 0.887077 | 0.00430974 | 33.8315

# IfcBeam: K80/3 (76)
In: Undefined
Description: K80/3; Material: STEEL/S275JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no
Default - MATERIAL: S275JR; NAME: Koppelkoker
Tekla Common - Phase: 1010; Class: 9
Tekla Quantity - Area per tons: 43.492 m2; Height: 80 mm; Width: 80 mm
Name | Reference | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Koppelkoker | A0(?) | +4.242 | +4.322 | 21.87 | 0.003 | 0.245 | 0.981 | 3068 | 3068.01 | 0.951083 | 0.00282936 | 22.2105
2 x Koppelkoker | A0(?) | +4.242 | +4.322 | 20.04 | 0.003 | 0.225 | 0.901 | 2812 | 2811.97 | 0.87171 | 0.00259826 | 20.3963
Koppelkoker | A0(?) | +4.202 | +4.322 | 23.08 | 0.003 | 0 | 1.037 | 3238.1 | 3238.11 | 1.00381 | 0.00299201 | 23.4873
Koppelkoker | A0(?) | +4.242 | +4.322 | 21.62 | 0.003 | 0.243 | 0.972 | 3033.4 | 3033.39 | 0.94035 | 0.00280285 | 22.0024
Koppelkoker | A0(?) | +4.242 | +4.322 | 21.7 | 0.003 | 0.244 | 0.975 | 3044.9 | 3044.91 | 0.943922 | 0.0028135 | 22.0859
2 x Koppelkoker | A0(?) | +4.242 | +4.322 | 20.04 | 0.003 | 0.225 | 0.901 | 2812.2 | 2812.17 | 0.871773 | 0.00259845 | 20.3978
2 x Koppelkoker | A0(?) | +4.242 | +4.322 | 21.15 | 0.003 | 0.237 | 0.95 | 2966.9 | 2966.87 | 0.919729 | 0.00274139 | 21.5199
Koppelkoker | A-20(?) | +4.994 | +5.094 | 15.04 | 0.002 | 0 | 0.676 | 2109.7 | 2109.65 | 0.653993 | 0.00194932 | 15.3022
Koppelkoker | A-20(?) | +4.751 | +5.412 | 35.93 | 0.005 | 0 | 1.614 | 5041.3 | 5041.29 | 1.5628 | 0.00465815 | 36.5665
Koppelkoker | A-20(?) | +5.316 | +5.417 | 21.45 | 0.003 | 0 | 0.964 | 3008.7 | 3008.73 | 0.932705 | 0.00278006 | 21.8235
Koppelkoker | A-20(?) | +5.356 | +5.993 | 14.33 | 0.002 | 0 | 0.644 | 2010.3 | 2010.29 | 0.623188 | 0.0018575 | 14.5814
Koppelkoker | A-20(?) | +5.355 | +5.993 | 16.78 | 0.002 | 0 | 0.754 | 2354.7 | 2354.65 | 0.729942 | 0.0021757 | 17.0792
Koppelkoker | A-20(?) | +4.089 | +4.308 | 24.17 | 0.003 | 0 | 1.082 | 3390.4 | 3390.51 | 1.05106 | 0.00312179 | 24.5061
2 x Koppelkoker | A-20(?) | +5.352 | +5.432 | 32.44 | 0.004 | 0.364 | 1.457 | 4551 | 4551.04 | 1.41082 | 0.00420516 | 33.0105
2 x Koppelkoker | A-20(?) | +3.995 | +4.075 | 32.44 | 0.004 | 0.364 | 1.457 | 4551 | 4551.04 | 1.41082 | 0.00420516 | 33.0105
Koppelkoker | A0(?) | +4.242 | +4.322 | 23.27 | 0.003 | 0.261 | 1.046 | 3264.9 | 3264.88 | 1.01211 | 0.00301675 | 23.6815
Koppelkoker | A0(?) | +4.242 | +4.322 | 21.62 | 0.003 | 0.243 | 0.972 | 3033.4 | 3033.45 | 0.94037 | 0.00280291 | 22.0028
Koppelkoker | A0(?) | +4.242 | +4.322 | 21.7 | 0.003 | 0.244 | 0.975 | 3044.9 | 3044.85 | 0.943902 | 0.00281344 | 22.0855
Koppelkoker | A0(?) | +5.950 | +6.030 | 30.54 | 0.004 | 0.343 | 1.372 | 4284 | 4283.98 | 1.32803 | 0.0039584 | 31.0734
Koppelkoker | A0(?) | +5.950 | +6.030 | 30.3 | 0.004 | 0.34 | 1.361 | 4250.7 | 4250.71 | 1.31772 | 0.00392765 | 30.8321
Koppelkoker | A-20(?) | +5.408 | +5.565 | 17.64 | 0.002 | 0 | 0.793 | 2475.1 | 2475.13 | 0.76729 | 0.00228702 | 17.9531
Koppelkoker | A-20(?) | +5.385 | +5.583 | 17.64 | 0.002 | 0 | 0.793 | 2475 | 2474.96 | 0.767238 | 0.00228686 | 17.9519
Koppelkoker | A-20(?) | +5.387 | +5.585 | 17.64 | 0.002 | 0 | 0.793 | 2474.3 | 2474.33 | 0.767043 | 0.00228628 | 17.9473
Koppelkoker | A-20(?) | +5.382 | +5.588 | 17.65 | 0.002 | 0 | 0.794 | 2477 | 2476.97 | 0.767861 | 0.00228872 | 17.9665
Koppelkoker | A-20(?) | +5.373 | +5.588 | 17.65 | 0.002 | 0 | 0.793 | 2475.9 | 2475.87 | 0.767519 | 0.0022877 | 17.9585
Koppelkoker | A-20(?) | +4.097 | +4.223 | 15.74 | 0.002 | 0 | 0.707 | 2208.2 | 2208.16 | 0.68453 | 0.00203974 | 16.0119
Koppelkoker | A-20(?) | +4.125 | +4.226 | 15.8 | 0.002 | 0 | 0.708 | 2216 | 2216.05 | 0.686975 | 0.00204033 | 16.0166
Koppelkoker | A-20(?) | +4.097 | +4.229 | 12.91 | 0.002 | 0 | 0.578 | 1810.7 | 1810.66 | 0.561304 | 0.00166729 | 13.0882
Koppelkoker | A-20(?) | +4.101 | +4.351 | 24.04 | 0.003 | 0 | 1.077 | 3372.3 | 3372.26 | 1.0454 | 0.00310678 | 24.3882
Koppelkoker | A-20(?) | +4.142 | +4.356 | 23.98 | 0.003 | 0 | 1.074 | 3364.3 | 3364.35 | 1.04295 | 0.00309927 | 24.3292
Koppelkoker | A-20(?) | +4.141 | +4.367 | 23.98 | 0.003 | 0 | 1.074 | 3364.5 | 3364.5 | 1.04299 | 0.00309876 | 24.3253
Koppelkoker | A-20(?) | +4.157 | +4.366 | 23.81 | 0.003 | 0 | 1.07 | 3340.5 | 3340.48 | 1.03555 | 0.00308661 | 24.2299
Koppelkoker | A-20(?) | +4.157 | +4.321 | 23.84 | 0.003 | 0 | 1.07 | 3344.4 | 3344.44 | 1.03678 | 0.00308869 | 24.2462
Koppelkoker | A-20(?) | +4.132 | +4.327 | 26.16 | 0.003 | 0 | 1.173 | 3670.3 | 3670.33 | 1.1378 | 0.00338392 | 26.5638
Koppelkoker | A-20(?) | +5.371 | +5.539 | 21.78 | 0.003 | 0 | 0.979 | 3056.3 | 3056.29 | 0.94745 | 0.00282401 | 22.1685
Koppelkoker | A-20(?) | +5.369 | +5.474 | 9.37 | 0.001 | 0 | 0.422 | 1314.8 | 1314.76 | 0.407576 | 0.00121484 | 9.5365
Koppelkoker | A-20(?) | +5.333 | +5.468 | 11.54 | 0.001 | 0 | 0.519 | 1619.4 | 1619.41 | 0.502017 | 0.00149633 | 11.7462
Koppelkoker | A-20(?) | +5.333 | +5.457 | 11.54 | 0.001 | 0 | 0.519 | 1619.8 | 1619.8 | 0.502137 | 0.00149669 | 11.749
Koppelkoker | A-20(?) | +5.002 | +5.316 | 15.97 | 0.002 | 0 | 0.71 | 2240.7 | 2240.69 | 0.694613 | 0.00204661 | 16.0659
Koppelkoker | A-20(?) | +3.955 | +4.249 | 26.58 | 0.003 | 0 | 1.19 | 3728.4 | 3728.44 | 1.15582 | 0.00343242 | 26.9445
Koppelkoker | A-20(?) | +4.087 | +4.250 | 24.19 | 0.003 | 0 | 1.082 | 3393.7 | 3393.65 | 1.05203 | 0.00312513 | 24.5323
Koppelkoker | A-20(?) | +4.089 | +4.308 | 24.16 | 0.003 | 0 | 1.082 | 3389.5 | 3389.47 | 1.05073 | 0.0031209 | 24.4991
Koppelkoker | A-20(?) | +4.094 | +4.298 | 24.13 | 0.003 | 0 | 1.081 | 3385.8 | 3385.78 | 1.04959 | 0.00311872 | 24.4819
Koppelkoker | A-20(?) | +4.095 | +4.305 | 24.16 | 0.003 | 0 | 1.082 | 3389.3 | 3389.31 | 1.05069 | 0.00312191 | 24.507
Koppelkoker | A-20(?) | +4.092 | +4.195 | 12.88 | 0.002 | 0 | 0.578 | 1807.5 | 1807.54 | 0.560337 | 0.00166696 | 13.0856
Koppelkoker | A-20(?) | +5.373 | +5.575 | 17.69 | 0.002 | 0 | 0.795 | 2482.6 | 2482.62 | 0.769612 | 0.00229394 | 18.0074
Koppelkoker | A-20(?) | +5.382 | +5.578 | 17.64 | 0.002 | 0 | 0.793 | 2475.1 | 2475.2 | 0.767311 | 0.00228708 | 17.9536
Koppelkoker | A-20(?) | +5.382 | +5.578 | 17.64 | 0.002 | 0 | 0.793 | 2474.3 | 2474.42 | 0.76707 | 0.00228636 | 17.9479
Koppelkoker | A-20(?) | +5.379 | +5.575 | 17.63 | 0.002 | 0 | 0.792 | 2472.8 | 2472.8 | 0.766568 | 0.00228487 | 17.9362
Koppelkoker | A-20(?) | +5.356 | +5.473 | 9.32 | 0.001 | 0 | 0.419 | 1307.5 | 1307.46 | 0.405314 | 0.0012081 | 9.48356
Koppelkoker | A-20(?) | +3.947 | +4.187 | 28.46 | 0.004 | 0 | 1.276 | 3992.3 | 3992.26 | 1.2376 | 0.00368032 | 28.8905
Koppelkoker | A-20(?) | +5.223 | +5.519 | 28.6 | 0.004 | 0 | 1.282 | 4014 | 4013.96 | 1.24433 | 0.00370296 | 29.0682
Koppelkoker | A-20(?) | +5.381 | +5.519 | 24.1 | 0.003 | 0 | 1.082 | 3381.1 | 3381.12 | 1.04815 | 0.00312222 | 24.5094
Koppelkoker | A-20(?) | +3.946 | +4.532 | 30.54 | 0.004 | 0 | 1.362 | 4284.8 | 4284.83 | 1.3283 | 0.00393002 | 30.8507
Koppelkoker | A-20(?) | +3.947 | +4.048 | 24.08 | 0.003 | 0 | 1.082 | 3378.2 | 3378.2 | 1.04724 | 0.00312146 | 24.5034
Koppelkoker | A-20(?) | +5.378 | +5.536 | 17.64 | 0.002 | 0 | 0.793 | 2475.1 | 2475.18 | 0.767305 | 0.00228707 | 17.9535
Koppelkoker | A-20(?) | +5.418 | +5.548 | 21.33 | 0.003 | 0 | 0.958 | 2991.9 | 2991.87 | 0.927478 | 0.00276448 | 21.7012
Koppelkoker | A0(?) | +6.056 | +6.136 | 36.19 | 0.005 | 0.406 | 1.262 | 5077.5 | 5077.55 | 1.57404 | 0.0035949 | 28.22
Koppelkoker | A0(?) | +6.056 | +6.136 | 29.12 | 0.004 | 0.327 | 1.015 | 4085.1 | 4085.11 | 1.26638 | 0.00289226 | 22.7042
Koppelkoker | A-20(?) | +3.843 | +4.983 | 24.53 | 0.003 | 0 | 1.103 | 3442.5 | 3442.48 | 1.06717 | 0.00318085 | 24.9697
Koppelkoker | A-20(?) | +4.953 | +6.134 | 24.97 | 0.003 | 0 | 1.122 | 3502.6 | 3502.63 | 1.08582 | 0.00323643 | 25.406
Koppelkoker | A-20(?) | +2.957 | +3.874 | 22.64 | 0.003 | 0 | 1.018 | 3176.8 | 3176.77 | 0.984799 | 0.00293534 | 23.0424
Koppelkoker | A0(?) | +2.895 | +2.975 | 28.38 | 0.004 | 0.319 | 0.981 | 3982.1 | 3982.1 | 1.23445 | 0.00279543 | 21.9442
Koppelkoker | A-20(?) | +4.750 | +4.851 | 33.77 | 0.004 | 0 | 1.517 | 4737.8 | 4737.85 | 1.46873 | 0.00437776 | 34.3654
Koppelkoker | A-20(?) | +3.876 | +4.000 | 27.34 | 0.003 | 0 | 1.228 | 3835.5 | 3835.45 | 1.18899 | 0.00354341 | 27.8158
Koppelkoker | A-20(?) | +3.892 | +3.993 | 21.46 | 0.003 | 0 | 0.964 | 3010.3 | 3010.34 | 0.933206 | 0.00278155 | 21.8352
Koppelkoker | A-20(?) | +3.892 | +3.993 | 33.81 | 0.004 | 0 | 1.52 | 4742.9 | 4742.86 | 1.47029 | 0.00438239 | 34.4018
Koppelkoker | A-20(?) | +3.892 | +3.993 | 28.77 | 0.004 | 0 | 1.293 | 4036.8 | 4036.8 | 1.25141 | 0.00373 | 29.2805
Koppelkoker | A-20(?) | +4.746 | +4.851 | 28.67 | 0.004 | 0 | 1.288 | 4021.9 | 4021.9 | 1.24679 | 0.00371615 | 29.1717
Koppelkoker | A-20(?) | +5.316 | +5.417 | 27.16 | 0.003 | 0 | 0.837 | 3810.2 | 3810.18 | 1.18115 | 0.00234462 | 18.4053

# IfcBeam: L200/100/10 (2)
In: Undefined
Description: L200/100/10; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Phase: 1010; Class: 10
Tekla Quantity - Area per tons: 26.356 m2; Height: 200 mm; Width: 100 mm
Name | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | +2.856 | +3.056 | 62.93 | 0.008 | 0.028 | 1.664 | 2764.2 | 2764.21 | 1.65852 | 0.0080162 | 62.9272
Ligger | +2.870 | +3.070 | 19.51 | 0.002 | 0.009 | 0.52 | 857.1 | 857.11 | 0.514266 | 0.00248562 | 19.5121

# IfcBeam: L200/12, Oplegging
In: Undefined
Description: L200/12; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: Oplegging
Tekla Common - Bottom elevation: +5.875; Top elevation: +6.158; Phase: 1010; Class: 13
Tekla Quantity - Weight: 438.67 kg; Volume: 0.056 m3; Gross footprint area: 0 m2; Area per tons: 21.48 m2; Net surface area: 9.611 m2; Height: 200 mm; Width: 200 mm; Length: 12003.5 mm
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: HH0(?)
BaseQuantities - Length: 12003.5 mm; OuterSurfaceArea: 9.42274 m2; NetVolume: 0.0558812 m3; NetWeight: 438.668 kg

# IfcBeam: L60/6 (88)
In: Undefined
Description: L60/6; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no
Default - MATERIAL: S235JR; NAME: Windverband
Tekla Common - Phase: 1010; Class: 8
Tekla Quantity - Height: 60 mm; Width: 60 mm
Name | Reference | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Windverband | A0(?) | +4.262 | +4.322 | 23.51 | 0.003 | 0.263 | 44.698 | 1.052 | 4379.2 | 4379.17 | 1.051 | 0.00299535 | 23.5135
Windverband | A0(?) | +4.262 | +4.322 | 23.48 | 0.003 | 0.262 | 44.698 | 1.051 | 4372.5 | 4372.53 | 1.04941 | 0.00299081 | 23.4779
Windverband | A0(?) | +4.262 | +4.322 | 23.47 | 0.003 | 0.262 | 44.698 | 1.051 | 4371.5 | 4371.5 | 1.04916 | 0.0029901 | 23.4723
Windverband | A0(?) | +4.262 | +4.322 | 25.4 | 0.003 | 0.284 | 44.698 | 1.137 | 4729.7 | 4729.72 | 1.13513 | 0.00323513 | 25.3958
Windverband | A0(?) | +4.262 | +4.322 | 23.35 | 0.003 | 0.261 | 44.698 | 1.045 | 4348.4 | 4348.38 | 1.04361 | 0.00297429 | 23.3482
2 x Windverband | A0(?) | +4.262 | +4.322 | 24.71 | 0.003 | 0.276 | 44.698 | 1.106 | 4602 | 4601.99 | 1.10448 | 0.00314776 | 24.7099
Windverband | A0(?) | +4.262 | +4.322 | 22.86 | 0.003 | 0.255 | 44.698 | 1.023 | 4257.3 | 4257.35 | 1.02176 | 0.00291203 | 22.8594
Windverband | A0(?) | +4.262 | +4.322 | 23.48 | 0.003 | 0.262 | 44.698 | 1.051 | 4372.5 | 4372.46 | 1.04939 | 0.00299076 | 23.4775
Windverband | A0(?) | +4.262 | +4.322 | 23.47 | 0.003 | 0.262 | 44.698 | 1.051 | 4371.5 | 4371.42 | 1.04914 | 0.00299005 | 23.4719
Windverband | A0(?) | +4.262 | +4.322 | 24.76 | 0.003 | 0.277 | 44.698 | 1.108 | 4610.8 | 4610.83 | 1.1066 | 0.00315381 | 24.7574
Windverband | A-20(?) | +5.152 | +6.164 | 19.14 | 0.002 | 0 | 44.698 | 0.857 | 3564.7 | 3564.67 | 0.855522 | 0.00243824 | 19.1402
2 x Windverband | A-20(?) | +4.948 | +6.163 | 22.67 | 0.003 | 0 | 44.698 | 1.014 | 4221.2 | 4221.22 | 1.01309 | 0.00288732 | 22.6654
Windverband | A-20(?) | +4.949 | +6.164 | 22.49 | 0.003 | 0 | 44.698 | 1.007 | 4189.1 | 4189.15 | 1.00539 | 0.00286538 | 22.4932
Windverband | A-20(?) | +5.245 | +6.174 | 25.07 | 0.003 | 0 | 44.698 | 1.122 | 4668.4 | 4668.44 | 1.12042 | 0.00319321 | 25.0667
Windverband | A-20(?) | +5.244 | +6.173 | 25.07 | 0.003 | 0 | 44.698 | 1.122 | 4668.4 | 4668.44 | 1.12042 | 0.00319321 | 25.0667
Windverband | A-20(?) | +3.854 | +5.303 | 29.14 | 0.004 | 0 | 44.698 | 1.304 | 5427.6 | 5427.56 | 1.30261 | 0.00371245 | 29.1427
Windverband | A0(?) | +4.262 | +4.322 | 23.35 | 0.003 | 0.261 | 44.698 | 1.045 | 4348.4 | 4348.45 | 1.04363 | 0.00297434 | 23.3486
Windverband | A-20(?) | +5.302 | +6.113 | 20.27 | 0.003 | 0 | 44.698 | 0.908 | 3775.6 | 3775.64 | 0.906155 | 0.00258254 | 20.2729
Windverband | A-20(?) | +5.369 | +6.131 | 19.78 | 0.003 | 0 | 44.698 | 0.886 | 3684.2 | 3684.24 | 0.884219 | 0.00252002 | 19.7822
Windverband | A-10(?) | +2.782 | +4.240 | 31.9 | 0.004 | 0 | 44.698 | 1.427 | 5940.9 | 5940.94 | 1.42583 | 0.0040636 | 31.8993
Windverband | A-10(?) | +2.790 | +4.233 | 31.42 | 0.004 | 0 | 44.698 | 1.406 | 5852.4 | 5852.43 | 1.40458 | 0.00400306 | 31.424
Windverband | A-20(?) | +4.175 | +5.494 | 25.4 | 0.003 | 0 | 44.698 | 1.137 | 4732.3 | 4732.32 | 1.13576 | 0.00323691 | 25.4097
Windverband | A-20(?) | +4.182 | +5.361 | 26.89 | 0.003 | 0 | 44.698 | 1.203 | 5007.5 | 5007.47 | 1.20179 | 0.00342511 | 26.8871
Windverband | A-20(?) | +5.510 | +6.258 | 18.05 | 0.002 | 0 | 44.698 | 0.808 | 3362.6 | 3362.57 | 0.807017 | 0.0023 | 18.055
Windverband | A-20(?) | +5.537 | +6.249 | 16.83 | 0.002 | 0 | 44.698 | 0.754 | 3134.4 | 3134.38 | 0.752251 | 0.00214392 | 16.8297
Windverband | A-10(?) | +2.790 | +4.279 | 31.63 | 0.004 | 0 | 44.698 | 1.416 | 5891.3 | 5891.32 | 1.41392 | 0.00402966 | 31.6329
Windverband | A-10(?) | +2.774 | +4.279 | 31.4 | 0.004 | 0 | 44.698 | 1.405 | 5848.5 | 5848.47 | 1.40363 | 0.00400036 | 31.4028
Windverband | A-20(?) | +4.220 | +5.377 | 25.01 | 0.003 | 0 | 44.698 | 1.119 | 4658.3 | 4658.26 | 1.11798 | 0.00318625 | 25.0121
Windverband | A-20(?) | +4.222 | +5.508 | 25.17 | 0.003 | 0 | 44.698 | 1.127 | 4688.3 | 4688.32 | 1.1252 | 0.00320681 | 25.1735
Windverband | A-20(?) | +5.319 | +6.201 | 17.69 | 0.002 | 0 | 44.698 | 0.792 | 3294.3 | 3294.25 | 0.79062 | 0.00225327 | 17.6882
Windverband | A-20(?) | +5.425 | +6.251 | 16.36 | 0.002 | 0 | 44.698 | 0.733 | 3047.4 | 3047.44 | 0.731387 | 0.00208445 | 16.3629
Windverband | A-10(?) | +2.768 | +4.269 | 31.55 | 0.004 | 0 | 44.698 | 1.411 | 5875.2 | 5875.16 | 1.41004 | 0.00401861 | 31.5461
Windverband | A-10(?) | +2.763 | +4.264 | 31.51 | 0.004 | 0 | 44.698 | 1.41 | 5868.2 | 5868.16 | 1.40836 | 0.00401382 | 31.5085
Windverband | A0(?) | +4.207 | +5.369 | 25.26 | 0.003 | 0 | 44.698 | 1.13 | 4704.1 | 4704.13 | 1.12899 | 0.00321762 | 25.2583
Windverband | A-20(?) | +4.210 | +5.377 | 25.17 | 0.003 | 0 | 44.698 | 1.127 | 4689.1 | 4689.09 | 1.12538 | 0.00320734 | 25.1776
Windverband | A-20(?) | +5.306 | +6.065 | 15.35 | 0.002 | 0 | 44.698 | 0.687 | 2858.8 | 2858.75 | 0.6861 | 0.00195539 | 15.3498
Windverband | A-20(?) | +5.271 | +6.112 | 15.26 | 0.002 | 0 | 44.698 | 0.683 | 2841.2 | 2841.22 | 0.681893 | 0.0019434 | 15.2557
Windverband | A-20(?) | +5.294 | +6.064 | 15.35 | 0.002 | 0 | 44.698 | 0.687 | 2857 | 2856.98 | 0.685676 | 0.00195418 | 15.3403
Windverband | A-20(?) | +5.271 | +6.107 | 15.23 | 0.002 | 0 | 44.698 | 0.682 | 2835.8 | 2835.81 | 0.680594 | 0.00193969 | 15.2266
Windverband | A-10(?) | +2.778 | +4.137 | 26.37 | 0.003 | 0 | 44.698 | 1.18 | 4910.9 | 4910.87 | 1.17861 | 0.00335903 | 26.3684
Windverband | A-10(?) | +2.813 | +4.137 | 26.33 | 0.003 | 0 | 44.698 | 1.178 | 4903.7 | 4903.73 | 1.1769 | 0.00335415 | 26.3301
Windverband | A-20(?) | +4.080 | +5.364 | 23.4 | 0.003 | 0 | 44.698 | 1.046 | 4357.9 | 4357.89 | 1.04589 | 0.0029808 | 23.3993
Windverband | A-20(?) | +4.074 | +5.376 | 23.39 | 0.003 | 0 | 44.698 | 1.046 | 4356.9 | 4356.85 | 1.04565 | 0.00298009 | 23.3937
Windverband | A-20(?) | +4.102 | +5.402 | 28.65 | 0.004 | 0 | 44.698 | 1.282 | 5336.6 | 5336.59 | 1.28078 | 0.00365023 | 28.6543
Windverband | A-20(?) | +5.343 | +6.113 | 19.49 | 0.002 | 0 | 44.698 | 0.873 | 3629.9 | 3629.9 | 0.871177 | 0.00248285 | 19.4904
Windverband | A-20(?) | +5.372 | +6.113 | 19.76 | 0.003 | 0 | 44.698 | 0.885 | 3679.7 | 3679.75 | 0.88314 | 0.00251695 | 19.758
Windverband | A-20(?) | +5.315 | +6.201 | 17.67 | 0.002 | 0 | 44.698 | 0.791 | 3291.2 | 3291.23 | 0.789894 | 0.0022512 | 17.6719
Windverband | A-20(?) | +5.412 | +6.192 | 16.34 | 0.002 | 0 | 44.698 | 0.732 | 3043.4 | 3043.44 | 0.730425 | 0.00208171 | 16.3414
Windverband | A-20(?) | +5.316 | +6.202 | 17.67 | 0.002 | 0 | 44.698 | 0.791 | 3291.4 | 3291.42 | 0.789941 | 0.00225133 | 17.6729
Windverband | A-20(?) | +5.413 | +6.231 | 16.39 | 0.002 | 0 | 44.698 | 0.734 | 3051.8 | 3051.76 | 0.732423 | 0.00208741 | 16.3861
Windverband | A-10(?) | +2.776 | +4.162 | 30.5 | 0.004 | 0 | 44.698 | 1.365 | 5680.6 | 5680.59 | 1.36334 | 0.00388552 | 30.5013
Windverband | A-10(?) | +2.789 | +4.160 | 30.45 | 0.004 | 0 | 44.698 | 1.362 | 5671.1 | 5671.13 | 1.36107 | 0.00387905 | 30.4506
Windverband | A-20(?) | +4.109 | +5.374 | 26.47 | 0.003 | 0 | 44.698 | 1.184 | 4928.2 | 4928.19 | 1.18276 | 0.00337088 | 26.4614
Windverband | A-20(?) | +5.148 | +6.293 | 26.88 | 0.003 | 0 | 44.698 | 1.203 | 5006.8 | 5006.79 | 1.20163 | 0.00342465 | 26.8835
Windverband | A-20(?) | +5.343 | +6.272 | 24.75 | 0.003 | 0 | 44.698 | 1.108 | 4609.4 | 4609.41 | 1.10626 | 0.00315284 | 24.7498
Windverband | A-20(?) | +3.901 | +5.402 | 31.34 | 0.004 | 0 | 44.698 | 1.402 | 5837.2 | 5837.19 | 1.40093 | 0.00399264 | 31.3422
Windverband | A-10(?) | +2.836 | +3.946 | 28.06 | 0.004 | 0 | 44.698 | 1.256 | 5226.7 | 5226.68 | 1.2544 | 0.00357505 | 28.0642
Windverband | A-10(?) | +2.780 | +3.960 | 26.25 | 0.003 | 0 | 44.698 | 1.175 | 4888.5 | 4888.49 | 1.17324 | 0.00334373 | 26.2483
Windverband | A-20(?) | +3.904 | +5.207 | 30.72 | 0.004 | 0 | 44.698 | 1.375 | 5721.5 | 5721.51 | 1.37316 | 0.00391351 | 30.7211
Windverband | A0(?) | +6.007 | +6.125 | 42.1 | 0.005 | 0 | 44.698 | 1.882 | 7838 | 7838 | 1.88112 | 0.00536119 | 42.0853
Windverband | A0(?) | +6.007 | +6.125 | 34 | 0.004 | 0 | 44.698 | 1.521 | 6332.1 | 6332.12 | 1.51971 | 0.00433117 | 33.9997
Windverband | A0(?) | +6.006 | +6.125 | 41.67 | 0.005 | 0 | 44.698 | 1.864 | 7760.9 | 7760.85 | 1.8626 | 0.00530842 | 41.6711
Windverband | A0(?) | +6.007 | +6.125 | 33.64 | 0.004 | 0 | 44.698 | 1.505 | 6265 | 6265 | 1.5036 | 0.00428526 | 33.6393
Windverband | A-20(?) | +3.801 | +4.906 | 31.99 | 0.004 | 0 | 44.698 | 1.431 | 5958.6 | 5958.56 | 1.43005 | 0.00407566 | 31.9939
Windverband | A-20(?) | +3.795 | +4.906 | 32.28 | 0.004 | 0 | 44.698 | 1.444 | 6012.3 | 6012.27 | 1.44295 | 0.00411239 | 32.2823
Windverband | A-10(?) | +2.894 | +3.796 | 30.64 | 0.004 | 0 | 44.698 | 1.371 | 5707.3 | 5707.33 | 1.36976 | 0.00390382 | 30.645
Windverband | A-20(?) | +4.894 | +6.027 | 31.83 | 0.004 | 0 | 44.698 | 1.424 | 5928.7 | 5928.69 | 1.42288 | 0.00405522 | 31.8335
Windverband | A-20(?) | +3.784 | +4.960 | 31.89 | 0.004 | 0 | 44.698 | 1.427 | 5938.7 | 5938.66 | 1.42528 | 0.00406205 | 31.8871
Windverband | A-20(?) | +3.784 | +4.901 | 31.99 | 0.004 | 0 | 44.698 | 1.431 | 5959 | 5959 | 1.43016 | 0.00407595 | 31.9962
Windverband | A-20(?) | +4.894 | +6.027 | 31.83 | 0.004 | 0 | 44.698 | 1.424 | 5927.8 | 5927.81 | 1.42267 | 0.00405462 | 31.8288
Windverband | A-10(?) | +2.895 | +3.796 | 30.75 | 0.004 | 0 | 44.698 | 1.376 | 5727.5 | 5727.54 | 1.37461 | 0.00391764 | 30.7535
Windverband | A-20(?) | +5.373 | +5.930 | 26.39 | 0.003 | 0 | 44.698 | 1.181 | 4915.3 | 4915.33 | 1.17968 | 0.00336209 | 26.3924
Windverband | A-20(?) | +5.362 | +5.930 | 26.36 | 0.003 | 0 | 44.698 | 1.18 | 4910 | 4910 | 1.1784 | 0.00335844 | 26.3637
Windverband | A-20(?) | +4.005 | +5.430 | 33.97 | 0.004 | 0 | 44.698 | 1.52 | 6325.8 | 6325.83 | 1.5182 | 0.00432687 | 33.9659
Windverband | A-20(?) | +2.919 | +4.077 | 31.51 | 0.004 | 0 | 44.698 | 1.41 | 5867.9 | 5867.92 | 1.4083 | 0.00401366 | 31.5072
Windverband | A-20(?) | +4.017 | +5.435 | 33.98 | 0.004 | 0 | 44.698 | 1.52 | 6328.8 | 6328.8 | 1.51891 | 0.0043289 | 33.9819
Windverband | A-20(?) | +2.910 | +4.077 | 31.46 | 0.004 | 0 | 44.698 | 1.406 | 5858.6 | 5858.65 | 1.40608 | 0.00400731 | 31.4574
Windverband | A-10(?) | +2.816 | +3.904 | 23.55 | 0.003 | 0 | 45.1 | 1.054 | 4425.3 | 4425.27 | 1.06206 | 0.00299991 | 23.5493
Windverband | A-20(?) | +3.846 | +4.762 | 29.48 | 0.004 | 0 | 44.698 | 1.319 | 5489.9 | 5489.89 | 1.31757 | 0.00375508 | 29.4774
Windverband | A-20(?) | +4.704 | +6.118 | 35.31 | 0.004 | 0 | 44.698 | 1.579 | 6575.5 | 6575.48 | 1.57812 | 0.00449763 | 35.3064
Windverband | A-20(?) | +4.703 | +6.119 | 35.33 | 0.005 | 0 | 44.698 | 1.581 | 6580.7 | 6580.72 | 1.57937 | 0.00450121 | 35.3345
Windverband | A-10(?) | +2.774 | +3.912 | 27.6 | 0.004 | 0 | 44.698 | 1.235 | 5139.6 | 5139.58 | 1.2335 | 0.00351547 | 27.5965
Windverband | A-10(?) | +2.774 | +3.905 | 31.5 | 0.004 | 0 | 44.698 | 1.41 | 5866.2 | 5866.22 | 1.40789 | 0.0040125 | 31.4981
Windverband | A-10(?) | +2.810 | +3.905 | 28.19 | 0.004 | 0 | 44.698 | 1.262 | 5251 | 5250.96 | 1.26023 | 0.00359165 | 28.1945
Windverband | A-20(?) | +3.846 | +4.758 | 26.36 | 0.003 | 0 | 44.698 | 1.18 | 4906.5 | 4906.51 | 1.17756 | 0.00335605 | 26.345
Windverband | A-20(?) | +3.854 | +5.303 | 31.8 | 0.004 | 0 | 44.698 | 1.424 | 5922 | 5922.04 | 1.42129 | 0.00405067 | 31.7978

# IfcBeam: L70/7 (8)
In: Undefined
Description: L70/7; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: Windverband
Pset_BeamCommon - IsExternal: no; LoadBearing: no
Tekla Common - Phase: 1010; Class: 7
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 38.312 m2; Height: 70 mm; Width: 70 mm
Name | Reference | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Windverband | A-10(?) | +2.745 | +4.213 | 42.41 | 0.005 | 1.627 | 5803.5 | 5803.5 | 1.62498 | 0.00540306 | 42.414
Windverband | A-10(?) | +2.766 | +4.219 | 42.1 | 0.005 | 1.614 | 5760.1 | 5760.14 | 1.61284 | 0.00536269 | 42.0971
Windverband | A-20(?) | +4.154 | +5.368 | 34.84 | 0.004 | 1.337 | 4766.7 | 4766.67 | 1.33467 | 0.00443777 | 34.8365
Windverband | A-20(?) | +4.139 | +5.373 | 34.99 | 0.004 | 1.342 | 4787.7 | 4787.69 | 1.34055 | 0.00445734 | 34.9901
Windverband | A-20(?) | +4.152 | +5.373 | 34.83 | 0.004 | 1.337 | 4765.8 | 4765.84 | 1.33444 | 0.004437 | 34.8304
