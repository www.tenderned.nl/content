Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcBeam: L70/7 (8)
Name | Reference | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Windverband | A-10(?) | +2.745 | +4.220 | 42.53 | 0.005 | 1.631 | 5819.4 | 5819.42 | 1.62944 | 0.00541788 | 42.5303
Windverband | A-10(?) | +2.766 | +4.220 | 42.49 | 0.005 | 1.631 | 5813.9 | 5813.9 | 1.62789 | 0.00541274 | 42.49
Windverband | A-20(?) | +4.147 | +5.374 | 34.86 | 0.004 | 1.338 | 4770.2 | 4770.24 | 1.33567 | 0.00444109 | 34.8626

# IfcBeam: UNP200 (4)
In: Undefined
Description: UNP200; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Bottom elevation: +2.852; Top elevation: +3.052; Phase: 1010; Class: 14
Tekla Quantity - Area per tons: 26.111 m2; Height: 200 mm; Width: 75 mm
Name | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Ligger | 108.71 | 0.013 | 0.323 | 2.9 | 4300.8 | 4300.8 | 2.83853 | 0.013695 | 107.505
Ligger | 59.01 | 0.008 | 0.175 | 1.577 | 2334.6 | 2334.6 | 1.54084 | 0.00743402 | 58.3571
Ligger | 105.14 | 0.013 | 0.312 | 2.805 | 4159.4 | 4159.37 | 2.74518 | 0.0132446 | 103.97
Ligger | 56.18 | 0.007 | 0.167 | 1.502 | 2222.5 | 2222.5 | 1.46685 | 0.00707706 | 55.555

# IfcBeam: UNP220, Ligger
In: Undefined
Description: UNP220; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; comment: Aaan bestaand verankeren; NAME: Ligger
Tekla Common - Bottom elevation: +2.842; Top elevation: +3.062; Phase: 1010; Class: 14
Tekla Quantity - Weight: 357.01 kg; Volume: 0.045 m3; Gross footprint area: 0.973 m2; Area per tons: 24.524 m2; Net surface area: 8.898 m2; Height: 220 mm; Width: 80 mm; Length: 12160 mm
BaseQuantities - Length: 12160 mm; OuterSurfaceArea: 8.7552 m2; NetVolume: 0.0450392 m3; NetWeight: 353.558 kg

# IfcBeam: UNP240, Ligger
In: Undefined
Description: UNP240; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_BeamCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S235JR; NAME: Ligger
Tekla Common - Bottom elevation: +2.816; Top elevation: +3.056; Phase: 1010; Class: 10
Tekla Quantity - Weight: 209.69 kg; Volume: 0.027 m3; Gross footprint area: 0.537 m2; Area per tons: 23.189 m2; Net surface area: 4.993 m2; Height: 240 mm; Width: 85 mm; Length: 6315 mm
BaseQuantities - Length: 6315 mm; OuterSurfaceArea: 4.86255 m2; NetVolume: 0.0264322 m3; NetWeight: 207.493 kg

# IfcBuildingElementProxy: D10, DUMMY
In: Undefined
Description: D10; Material: MISCELLANEOUS/DUMMY
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Ondersteuning; IFC_ENTITY: Auto
Default - MATERIAL: DUMMY; NAME: DUMMY
Tekla Common - Bottom elevation: +0.000; Top elevation: +0.100; Phase: 1010; Class: 100
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.003 m2; Height: 10 mm; Width: 10 mm; Length: 100 mm
Pours - Pour Weight Net: 0 kg; Pour Weight: 0 kg; Pour Volume: 0 m3; Pour Bottom Level: +0.000; Pour Top Level: +0.100; Pour Material: DUMMY; Pour Content Type: PART; Pour Area NGY: 0 m2; Pour Area PGY: 0 m2; Pour Area NXG: 0 m2; Pour Area PGX: 0 m2; Pour Area NGZ: 0 m2; Pour Area PGZ: 0 m2; Pour Area: 0 m2

# IfcColumn: B139.7/4 (13)
In: Undefined
Description: B139.7/4; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: Kolom
Pset_ColumnCommon - IsExternal: no; LoadBearing: no
Tekla Common - Phase: 1010
Tekla Quantity - Area per tons: 32.874 m2; Height: 139.7 mm; Width: 139.7 mm
Name | Reference | Bottom elevation | Top elevation | Class | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Kolom | A0(?) | -0.050 | +6.343 | 3 | 85.56 | 0.01 | 0 | 2.786 | 6392.8 | 6392.84 | 2.81285 | 0.0106849 | 83.8767
Kolom | A0(?) | -0.050 | +4.960 | 3 | 67.06 | 0.01 | 0.002 | 2.191 | 5010 | 5010 | 2.2044 | 0.00840349 | 65.9674
2 x Kolom | A0(?) | -0.050 | +3.883 | 3 | 52.64 | 0.007 | 0 | 1.711 | 3932.7 | 3932.72 | 1.7304 | 0.00655845 | 51.4839
Kolom | A0(?) | -0.050 | +6.343 | 3 | 85.56 | 0.01 | 0 | 2.786 | 6392.9 | 6392.94 | 2.81289 | 0.0106851 | 83.878
Kolom | A0(?) | -0.050 | +4.993 | 3 | 67.49 | 0.01 | 0 | 2.196 | 5042.8 | 5042.75 | 2.21881 | 0.00842037 | 66.0999
Kolom | A0(?) | -0.070 | +2.912 | 1 | 39.91 | 0.005 | 0.002 | 1.304 | 2982 | 2982 | 1.31208 | 0.00500184 | 39.2644
Kolom | A0(?) | -0.050 | +2.912 | 1 | 39.64 | 0.005 | 0.002 | 1.296 | 2962 | 2962 | 1.30328 | 0.00496829 | 39.0011
Kolom | A0(?) | -0.050 | +2.847 | 1 | 38.77 | 0.005 | 0 | 1.258 | 2896.5 | 2896.51 | 1.27447 | 0.00482038 | 37.84
Kolom | P0(?) | -0.035 | +3.883 | 1 | 52.44 | 0.007 | 0 | 1.704 | 3918.2 | 3918.2 | 1.72401 | 0.00653411 | 51.2928
Kolom | A0(?) | -0.050 | +2.837 | 1 | 38.63 | 0.005 | 0.002 | 1.263 | 2886.5 | 2886.5 | 1.27006 | 0.00484165 | 38.007
Kolom | P0(?) | -0.035 | +5.220 | 1 | 70.32 | 0.01 | 0.002 | 2.298 | 5255 | 5255 | 2.3122 | 0.00881444 | 69.1934
Kolom | P0(?) | -0.055 | +3.124 | 1 | 42.55 | 0.005 | 0 | 1.381 | 3179 | 3179 | 1.39876 | 0.00529422 | 41.5596

# IfcColumn: B139.7/6.3 (7)
In: Undefined
Description: B139.7/6.3; Material: STEEL/S275JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Pset_ColumnCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Default - MATERIAL: S275JR; NAME: Kolom
Tekla Common - Bottom elevation: -0.050; Phase: 1010; Class: 1
Tekla Quantity - Volume: 0.008 m3; Gross footprint area: 0 m2; Area per tons: 21.231 m2; Height: 139.7 mm; Width: 139.7 mm
Name | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Kolom | +3.138 | 66.07 | 1.386 | 3187.9 | 3187.92 | 1.40268 | 0.00822046 | 64.5306
Kolom | +3.144 | 66.19 | 1.389 | 3194.1 | 3194.06 | 1.40539 | 0.00823567 | 64.65
Kolom | +3.160 | 66.52 | 1.396 | 3209.7 | 3209.74 | 1.41229 | 0.0082767 | 64.9721
Kolom | +3.160 | 66.52 | 1.396 | 3209.5 | 3209.54 | 1.4122 | 0.00827619 | 64.9681
Kolom | +3.160 | 66.52 | 1.396 | 3209.7 | 3209.78 | 1.4123 | 0.00827681 | 64.9729
Kolom | +3.160 | 66.52 | 1.396 | 3209.5 | 3209.54 | 1.4122 | 0.00827617 | 64.968
Kolom | +3.161 | 66.54 | 1.396 | 3210.8 | 3210.79 | 1.41275 | 0.00827941 | 64.9934

# IfcColumn: B168.3/6.3 (7)
In: Undefined
Description: B168.3/6.3; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: Kolom
Tekla Common - Phase: 1010; Class: 3
Tekla Quantity - Volume: 0.018 m3; Gross footprint area: 0 m2; Area per tons: 21.059 m2; Height: 168.3 mm; Width: 168.3 mm
Pset_ColumnCommon - IsExternal: no; LoadBearing: no
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x Kolom | -0.035 | +5.470 | 138.55 | 2.891 | 5505.4 | P0(?) | 5505.4 | 2.91786 | 0.0173641 | 136.308
Kolom | -0.050 | +5.436 | 138.06 | 2.881 | 5485.8 | A0(?) | 5485.76 | 2.90745 | 0.0173013 | 135.816
Kolom | -0.050 | +5.754 | 146.06 | 3.049 | 5803.8 | A0(?) | 5803.76 | 3.07599 | 0.0183099 | 143.732
Kolom | -0.050 | +5.758 | 146.17 | 3.051 | 5807.8 | A0(?) | 5807.82 | 3.07814 | 0.0183227 | 143.834
Kolom | -0.050 | +5.471 | 138.96 | 2.9 | 5521.4 | A0(?) | 5521.36 | 2.92632 | 0.0174147 | 136.706
Kolom | -0.035 | +5.431 | 137.57 | 2.871 | 5466.4 | P0(?) | 5466.39 | 2.89719 | 0.0172404 | 135.337

# IfcColumn: HEA140 (122)
In: Undefined
Description: HEA140; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: Kolom
Tekla Common - Phase: 1010; Class: 1
Tekla Quantity - Area per tons: 32.05 m2; Height: 133 mm; Width: 140 mm
Pset_ColumnCommon - IsExternal: no; LoadBearing: no
Name | Bottom elevation | Top elevation | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
13 x Kolom | -0.050 | +3.052 | 76.46 | 0.01 | 0.003 | 2.534 | 3102 | A0(?) | 3102 | 2.45058 | 0.00936184 | 73.4904
4 x Kolom | +3.000 | +4.352 | 33.33 | 0.004 | 0.003 | 1.108 | 1352 | A0(?) | 1352 | 1.06808 | 0.00408034 | 32.0306
Kolom | +2.972 | +5.388 | 59.57 | 0.008 | 0.003 | 1.976 | 2416.8 | A0(?) | 2416.77 | 1.90925 | 0.00729363 | 57.255
Kolom | +3.056 | +4.757 | 41.93 | 0.005 | 0 | 1.375 | 1701 | A0(?) | 1701.04 | 1.34382 | 0.00506857 | 39.7883
Kolom | +2.977 | +4.753 | 43.79 | 0.006 | 0 | 1.436 | 1776.5 | A0(?) | 1776.49 | 1.40342 | 0.00529623 | 41.5754
Kolom | +3.052 | +4.753 | 41.93 | 0.005 | 0 | 1.375 | 1701.1 | A0(?) | 1701.13 | 1.3439 | 0.00506882 | 39.7902
Kolom | -0.050 | +4.219 | 105.22 | 0.013 | 0.003 | 3.485 | 4268.9 | A0(?) | 4268.9 | 3.37243 | 0.0128835 | 101.136
Kolom | -0.035 | +2.829 | 70.59 | 0.01 | 0.003 | 2.34 | 2863.6 | P0(?) | 2863.63 | 2.26226 | 0.00864242 | 67.843
Kolom | -0.050 | +2.870 | 71.98 | 0.01 | 0.003 | 2.386 | 2920 | A0(?) | 2920 | 2.3068 | 0.00881256 | 69.1786
5 x Kolom | -0.070 | +4.352 | 109 | 0.013 | 0.003 | 3.61 | 4422 | A0(?) | 4422 | 3.49338 | 0.0133456 | 104.763
Kolom | -0.050 | +4.102 | 102.35 | 0.013 | 0 | 3.372 | 4152.4 | A0(?) | 4152.38 | 3.28038 | 0.0124656 | 97.8546
Kolom | -0.050 | +6.250 | 155.3 | 0.02 | 0 | 5.123 | 6300.4 | A0(?) | 6300.41 | 4.97733 | 0.0189483 | 148.744
Kolom | -0.050 | +5.352 | 133.17 | 0.017 | 0 | 4.391 | 5402.5 | A0(?) | 5402.46 | 4.26795 | 0.0162383 | 127.471
Kolom | -0.050 | +2.783 | 69.84 | 0.01 | 0 | 2.298 | 2833.2 | A0(?) | 2833.2 | 2.23823 | 0.00848543 | 66.6106
Kolom | -0.235 | +1.938 | 53.56 | 0.007 | 0 | 1.759 | 2172.9 | P0(?) | 2172.94 | 1.71662 | 0.00648933 | 50.9412 | Default - comment: ingeklemd op fundering
Kolom | -0.250 | +1.289 | 37.93 | 0.005 | 0 | 1.242 | 1538.6 | A0(?) | 1538.61 | 1.2155 | 0.00457495 | 35.9133 | Default - comment: ingeklemd op fundering
Kolom | -0.250 | +0.639 | 21.92 | 0.003 | 0 | 0.712 | 889.3 | A0(?) | 889.292 | 0.702541 | 0.0026153 | 20.5301 | Default - comment: ingeklemd op fundering
Kolom | +3.150 | +4.420 | 31.3 | 0.004 | 0.003 | 1.041 | 1270 | A0(?) | 1270 | 1.0033 | 0.00383286 | 30.088
Kolom | -0.050 | +4.070 | 101.55 | 0.013 | 0.003 | 3.364 | 4120 | A0(?) | 4120 | 3.2548 | 0.0124342 | 97.6082
Kolom | -0.050 | +4.552 | 113.43 | 0.013 | 0 | 3.738 | 4602 | A0(?) | 4601.95 | 3.63554 | 0.0138235 | 108.514
Kolom | -0.050 | +4.470 | 111.41 | 0.013 | 0.003 | 3.69 | 4520 | A0(?) | 4520 | 3.5708 | 0.0136414 | 107.085
5 x Kolom | -0.070 | +3.152 | 79.42 | 0.01 | 0.003 | 2.632 | 3222 | A0(?) | 3222 | 2.54538 | 0.009724 | 76.3334
Kolom | +3.152 | +6.301 | 77.61 | 0.01 | 0 | 2.554 | 3148.7 | A-20(?) | 3148.66 | 2.48744 | 0.00943772 | 74.0861
Kolom | -0.050 | +4.219 | 105.23 | 0.013 | 0.003 | 3.485 | 4268.9 | A0(?) | 4269 | 3.37251 | 0.0128838 | 101.138
Kolom | -0.050 | +6.346 | 157.66 | 0.02 | 0 | 5.201 | 6396.2 | A0(?) | 6396.2 | 5.053 | 0.0192385 | 151.023
2 x Kolom | -0.035 | +6.235 | 154.56 | 0.02 | 0 | 5.098 | 6270.5 | P0(?) | 6270.47 | 4.95367 | 0.0188556 | 148.017
Kolom | -0.050 | +2.845 | 71.36 | 0.01 | 0.003 | 2.365 | 2895 | A0(?) | 2895 | 2.28705 | 0.00873711 | 68.5863
Kolom | -0.050 | +2.822 | 70.79 | 0.01 | 0.003 | 2.347 | 2872 | A0(?) | 2872 | 2.26888 | 0.0086677 | 68.0414
Kolom | -0.070 | +2.912 | 73.5 | 0.01 | 0.003 | 2.436 | 2982 | A0(?) | 2982 | 2.35578 | 0.00899968 | 70.6475
Kolom | -0.050 | +4.352 | 108.5 | 0.013 | 0.003 | 3.594 | 4402 | A0(?) | 4402 | 3.47758 | 0.0132852 | 104.289
Kolom | -0.050 | +3.161 | 79.16 | 0.01 | 0 | 2.606 | 3211.4 | A0(?) | 3211.41 | 2.53701 | 0.00962661 | 75.5689
Kolom | +3.152 | +6.344 | 78.68 | 0.01 | 0 | 2.59 | 3192.1 | A-20(?) | 3192.07 | 2.52174 | 0.00956825 | 75.1108
Kolom | +3.152 | +6.343 | 78.64 | 0.01 | 0 | 2.59 | 3190.5 | A-20(?) | 3190.52 | 2.52051 | 0.0095636 | 75.0743
Kolom | +3.152 | +6.345 | 78.71 | 0.01 | 0 | 2.591 | 3193.2 | A-20(?) | 3193.19 | 2.52262 | 0.00957163 | 75.1373
Kolom | +3.152 | +6.342 | 78.63 | 0.01 | 0 | 2.588 | 3190.1 | A-20(?) | 3190.14 | 2.52021 | 0.0095624 | 75.0649
Kolom | +3.152 | +6.343 | 78.64 | 0.01 | 0 | 2.588 | 3190.6 | A-20(?) | 3190.56 | 2.52054 | 0.00956394 | 75.0769
Kolom | +3.152 | +6.371 | 79.35 | 0.01 | 0 | 2.612 | 3219.3 | A0(?) | 3219.31 | 2.54325 | 0.00965061 | 75.7573
Kolom | +3.152 | +6.376 | 79.47 | 0.01 | 0 | 2.616 | 3224 | A-20(?) | 3224.01 | 2.54697 | 0.00966542 | 75.8736
Kolom | +3.152 | +6.348 | 78.78 | 0.01 | 0 | 2.593 | 3196.1 | A-20(?) | 3196.11 | 2.52493 | 0.00958023 | 75.2048
Kolom | +3.152 | +6.342 | 78.63 | 0.01 | 0 | 2.588 | 3189.9 | A-20(?) | 3189.86 | 2.51999 | 0.00956157 | 75.0584
Kolom | +3.152 | +6.342 | 78.63 | 0.01 | 0 | 2.588 | 3189.6 | A-20(?) | 3189.59 | 2.51978 | 0.00956159 | 75.0585
Kolom | +3.152 | +6.342 | 78.63 | 0.01 | 0 | 2.588 | 3189.9 | A-20(?) | 3189.82 | 2.51996 | 0.00956147 | 75.0575
Kolom | +3.152 | +6.345 | 78.7 | 0.01 | 0 | 2.591 | 3192.9 | A-20(?) | 3192.91 | 2.5224 | 0.0095708 | 75.1308
Kolom | +3.152 | +6.344 | 78.68 | 0.01 | 0 | 2.59 | 3192.4 | A-20(?) | 3192.42 | 2.52201 | 0.00956894 | 75.1162
2 x Kolom | -0.050 | +2.912 | 73.01 | 0.01 | 0.003 | 2.42 | 2962 | A0(?) | 2962 | 2.33998 | 0.00893932 | 70.1736
Kolom | -0.050 | +5.370 | 133.6 | 0.017 | 0.003 | 4.423 | 5420 | A0(?) | 5420 | 4.2818 | 0.0163576 | 128.407
Kolom | -0.050 | +5.210 | 129.66 | 0.017 | 0 | 4.276 | 5260.2 | A0(?) | 5260.19 | 4.15555 | 0.0158101 | 124.109
2 x Kolom | -0.070 | +4.219 | 105.72 | 0.013 | 0.003 | 3.502 | 4289 | A0(?) | 4289 | 3.38831 | 0.0129442 | 101.612
2 x Kolom | -0.070 | +2.922 | 73.75 | 0.01 | 0.003 | 2.445 | 2991.9 | A0(?) | 2992 | 2.36368 | 0.00902986 | 70.8844
Kolom | -0.050 | +3.152 | 78.92 | 0.01 | 0 | 2.598 | 3201.9 | A0(?) | 3201.88 | 2.52949 | 0.00959808 | 75.345
2 x Kolom | -0.050 | +5.889 | 146.38 | 0.018 | 0.003 | 4.846 | 5938.7 | A0(?) | 5938.7 | 4.69157 | 0.017923 | 140.696
Kolom | -0.050 | +2.803 | 70.32 | 0.01 | 0.003 | 2.331 | 2853 | A0(?) | 2853 | 2.25387 | 0.00861035 | 67.5913
Kolom | -0.050 | +3.998 | 99.78 | 0.013 | 0 | 3.287 | 4048.1 | A0(?) | 4048.07 | 3.19798 | 0.0121485 | 95.3654
Kolom | -0.050 | +5.345 | 132.98 | 0.017 | 0 | 4.385 | 5394.9 | A0(?) | 5394.93 | 4.26199 | 0.0162133 | 127.274
Kolom | -0.050 | +3.008 | 75.38 | 0.01 | 0 | 2.481 | 3058.3 | A0(?) | 3058.31 | 2.41607 | 0.00916479 | 71.9436
Kolom | -0.050 | +6.078 | 151.05 | 0.018 | 0 | 4.983 | 6128.1 | A0(?) | 6128.11 | 4.84121 | 0.0184294 | 144.671
Kolom | -0.050 | +3.970 | 99.09 | 0.013 | 0 | 3.265 | 4019.9 | A0(?) | 4019.85 | 3.17568 | 0.0120667 | 94.7237
Kolom | -0.050 | +5.344 | 132.95 | 0.017 | 0 | 4.385 | 5393.8 | A0(?) | 5393.76 | 4.26107 | 0.0162132 | 127.273
Kolom | -0.050 | +3.008 | 75.38 | 0.01 | 0 | 2.481 | 3058.3 | A0(?) | 3058.28 | 2.41604 | 0.0091647 | 71.9429
Kolom | -0.050 | +6.078 | 151.05 | 0.018 | 0 | 4.983 | 6127.9 | A0(?) | 6127.86 | 4.84101 | 0.0184287 | 144.665
Kolom | -0.050 | +6.260 | 155.54 | 0.02 | 0 | 5.131 | 6310.3 | A0(?) | 6310.28 | 4.98512 | 0.0189758 | 148.96
Kolom | -0.035 | +5.304 | 131.59 | 0.017 | 0 | 4.339 | 5338.6 | P0(?) | 5338.56 | 4.21746 | 0.0160431 | 125.939
Kolom | -0.050 | +6.372 | 158.29 | 0.02 | 0 | 5.222 | 6421.7 | A0(?) | 6421.66 | 5.07312 | 0.0193154 | 151.626
Kolom | -0.050 | +6.355 | 157.87 | 0.02 | 0 | 5.209 | 6404.9 | A0(?) | 6404.91 | 5.05988 | 0.0192648 | 151.229
Kolom | -0.035 | +3.108 | 77.46 | 0.01 | 0 | 2.55 | 3142.5 | P0(?) | 3142.52 | 2.48259 | 0.00941896 | 73.9388
2 x Kolom | -0.050 | +6.351 | 157.78 | 0.02 | 0 | 5.205 | 6401 | A0(?) | 6400.96 | 5.05676 | 0.0192529 | 151.135
Kolom | -0.050 | +3.870 | 96.62 | 0.012 | 0.003 | 3.201 | 3920 | A0(?) | 3920 | 3.0968 | 0.0118306 | 92.8699
Kolom | -0.050 | +3.102 | 77.7 | 0.01 | 0 | 2.558 | 3152.2 | A0(?) | 3152.18 | 2.49022 | 0.00944808 | 74.1675
Kolom | -0.050 | +3.882 | 96.93 | 0.012 | 0 | 3.194 | 3932.4 | A0(?) | 3932.41 | 3.10661 | 0.0118028 | 92.6521
2 x Kolom | -0.050 | +6.004 | 149.23 | 0.018 | 0 | 4.922 | 6054.1 | A0(?) | 6054.15 | 4.78278 | 0.0182028 | 142.892
Kolom | -0.050 | +3.932 | 98.15 | 0.013 | 0 | 3.233 | 3981.8 | A0(?) | 3981.75 | 3.14558 | 0.0119517 | 93.821
Kolom | -0.050 | +3.105 | 77.77 | 0.01 | 0 | 2.56 | 3155.2 | A0(?) | 3155.19 | 2.4926 | 0.00945716 | 74.2387
2 x Kolom | -0.050 | +6.345 | 157.63 | 0.02 | 0 | 5.2 | 6394.8 | A0(?) | 6394.81 | 5.0519 | 0.0192343 | 150.99
Kolom | -0.050 | +3.920 | 97.86 | 0.012 | 0.003 | 3.242 | 3970 | A0(?) | 3970 | 3.1363 | 0.0119815 | 94.0545
Kolom | -0.050 | +4.092 | 102.09 | 0.013 | 0 | 3.364 | 4141.9 | A0(?) | 4141.94 | 3.27213 | 0.0124358 | 97.6209
Kolom | -0.050 | +4.073 | 101.62 | 0.013 | 0 | 3.348 | 4122.6 | A0(?) | 4122.59 | 3.25685 | 0.0123765 | 97.1558
Kolom | -0.050 | +4.073 | 101.62 | 0.013 | 0 | 3.349 | 4123.2 | A0(?) | 4123.21 | 3.25734 | 0.0123784 | 97.1706
Kolom | -0.050 | +3.820 | 95.39 | 0.012 | 0.003 | 3.16 | 3870 | A0(?) | 3870 | 3.0573 | 0.0116797 | 91.6853
Kolom | -0.035 | +3.105 | 77.4 | 0.01 | 0 | 2.548 | 3140.2 | P0(?) | 3140.19 | 2.48075 | 0.00941189 | 73.8834
Kolom | +3.152 | +6.345 | 78.71 | 0.01 | 0 | 2.591 | 3193.2 | A-20(?) | 3193.18 | 2.52262 | 0.00957162 | 75.1372
Kolom | -0.050 | +3.970 | 99.09 | 0.013 | 0.003 | 3.282 | 4019.9 | A0(?) | 4020 | 3.1758 | 0.0121324 | 95.239
Kolom | -0.050 | +3.163 | 79.2 | 0.01 | 0 | 2.607 | 3213.1 | A0(?) | 3213.05 | 2.53831 | 0.00963173 | 75.6091
Kolom | -0.050 | +4.072 | 101.6 | 0.013 | 0 | 3.348 | 4122 | A0(?) | 4122.04 | 3.25641 | 0.012375 | 97.1437
Kolom | -0.050 | +3.164 | 79.22 | 0.01 | 0 | 2.607 | 3213.8 | A0(?) | 3213.8 | 2.5389 | 0.00963402 | 75.627
Kolom | -0.050 | +4.063 | 101.39 | 0.013 | 0 | 3.341 | 4113.4 | A0(?) | 4113.4 | 3.24959 | 0.0123486 | 96.9364
Kolom | -0.050 | +4.095 | 102.16 | 0.013 | 0 | 3.367 | 4144.6 | A0(?) | 4144.63 | 3.27426 | 0.0124438 | 97.6839
Kolom | -0.050 | +3.197 | 80.04 | 0.01 | 0 | 2.635 | 3247 | A0(?) | 3247.04 | 2.56516 | 0.00973491 | 76.4191
Kolom | -0.050 | +3.149 | 78.85 | 0.01 | 0 | 2.596 | 3198.8 | A0(?) | 3198.82 | 2.52707 | 0.00958841 | 75.2691
Kolom | -0.050 | +3.161 | 79.16 | 0.01 | 0 | 2.606 | 3211.4 | A0(?) | 3211.35 | 2.53697 | 0.00962644 | 75.5676
Kolom | -0.050 | +3.198 | 80.06 | 0.01 | 0 | 2.635 | 3248.2 | A0(?) | 3248.18 | 2.56607 | 0.00973845 | 76.4468
Kolom | -0.050 | +3.161 | 79.16 | 0.01 | 0 | 2.606 | 3211.4 | A0(?) | 3211.34 | 2.53696 | 0.00962642 | 75.5674

# IfcColumn: HEA160 (16)
In: Undefined
Description: HEA160; Material: STEEL/S235JR
BIM Basis ILS - IS_EXTERNAL: Nee; LOAD_BEARING: Nee; IFC_ENTITY: Auto
Default - MATERIAL: S235JR; NAME: Kolom
Pset_ColumnCommon - IsExternal: no; LoadBearing: no; Reference: A0(?)
Tekla Common - Phase: 1010
Tekla Quantity - Area per tons: 29.885 m2; Height: 152 mm; Width: 160 mm
Name | Bottom elevation | Top elevation | Class | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
Kolom | -0.050 | +4.352 | 3 | 134.04 | 0.017 | 0.004 | 4.11 | 4402 | 4402 | 4.00582 | 0.016217 | 127.303
Kolom | -0.050 | +5.402 | 2 | 166.01 | 0.021 | 0 | 5.066 | 5451.9 | 5451.86 | 4.9612 | 0.0199937 | 156.951
Kolom | -0.050 | +5.329 | 3 | 163.78 | 0.021 | 0 | 4.998 | 5378.7 | 5378.72 | 4.89464 | 0.0197246 | 154.838
Kolom | -0.050 | +5.377 | 3 | 165.26 | 0.021 | 0 | 5.043 | 5427.2 | 5427.2 | 4.93875 | 0.0199037 | 156.244
Kolom | -0.050 | +5.656 | 3 | 173.76 | 0.021 | 0 | 5.303 | 5706.2 | 5706.21 | 5.19265 | 0.0209304 | 164.304
Kolom | -0.050 | +5.374 | 3 | 165.15 | 0.021 | 0 | 5.039 | 5423.6 | 5423.6 | 4.93548 | 0.0198893 | 156.131
Kolom | -0.050 | +5.373 | 3 | 165.15 | 0.021 | 0 | 5.039 | 5423.3 | 5423.34 | 4.93524 | 0.0198883 | 156.123
Kolom | -0.050 | +5.352 | 3 | 164.51 | 0.021 | 0 | 5.02 | 5402.5 | 5402.44 | 4.91622 | 0.0198116 | 155.521
Kolom | -0.050 | +5.364 | 3 | 164.85 | 0.021 | 0 | 5.03 | 5413.9 | 5413.86 | 4.92661 | 0.0198545 | 155.858
3 x Kolom | -0.070 | +6.070 | 3 | 186.96 | 0.024 | 0.004 | 5.73 | 6140 | 6140 | 5.5874 | 0.0226198 | 177.565
2 x Kolom | -0.050 | +6.070 | 3 | 186.35 | 0.024 | 0.004 | 5.711 | 6120 | 6120 | 5.5692 | 0.0225461 | 176.987
Kolom | -0.050 | +5.369 | 3 | 165.01 | 0.021 | 0 | 5.035 | 5419 | 5418.99 | 4.93129 | 0.019872 | 155.995
Kolom | -0.050 | +5.368 | 3 | 164.98 | 0.021 | 0 | 5.034 | 5418 | 5418.01 | 4.93039 | 0.0198689 | 155.971

# IfcElementAssembly (688)
In: Undefined
BIM Basis ILS - IS_EXTERNAL: Nee; IFC_ENTITY: Auto
Tekla Assembly - Phase: 1010
Name | LOAD_BEARING | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Ligger | Nee | 229 | +3.009 | +3.142 | F-G/O-P | A0(?) | 140
Ligger | Nee | 102.7 | +2.919 | +3.052 | G-H/S | A0(?) | 140
Ligger | Nee | 229 | +3.009 | +3.142 | F-G/4 | A0(?) | 140
Ligger | Nee | 102.7 | +2.919 | +3.052 | C-D/O | A0(?) | 140
Ligger | Nee | 102.7 | +2.919 | +3.052 | C-D/4 | A0(?) | 140
Ligger | Nee | 102.7 | +2.919 | +3.052 | C-D/R | A0(?) | 140
Ligger | Nee | 65.9 | +5.357 | +6.345 | V-U/T-5 | A-20(?) | 110
Ligger | Nee | 298.3 | +2.834 | +5.656 | V-G/T-6 | A-20(?) | 135
Ligger | Nee | 56.1 | +5.470 | +6.342 | K-G/T-5 | A-20(?) | 110
Ligger | Nee | 310.1 | +2.830 | +5.754 | K-H/T-6 | A-20(?) | 135
Kolom | Nee | 145.3 | -0.050 | +5.470 | G-H/S-T | A0(?) | 240
Ligger | Nee | 56 | +5.470 | +6.342 | K-H/S-T | A-20(?) | 110
Ligger | Nee | 310.2 | +2.830 | +5.754 | G-H/S-5 | A-20(?) | 135
2 x Kolom | Nee | 76.5 | -0.050 | +3.052 | B/3 | A0(?) | 140
Koppelkoker | Nee | 21.9 | +4.242 | +4.322 | E-F/R-S | A0(?) | 80
Koppelkoker | Nee | 21.9 | +4.242 | +4.322 | E-F/M-N | A0(?) | 80
Ligger | Nee | 62.9 | +2.856 | +3.056 | B-C/5 | A0(?) | 100
Ligger | Nee | 19.5 | +2.870 | +3.070 | C-D/5 | A0(?) | 100
Ligger | Nee | 209.7 | +2.816 | +3.056 | B-D/5-6 | A0(?) | 85
Kolom | Nee | 33.3 | +3.000 | +4.352 | F/R-S | A0(?) | 140
Windverband | Nee | 13.4 | +3.042 | +4.262 | F/R-S | A0(?) | 110
Windverband | Nee | 33.3 | +3.018 | +4.301 | F/P-S | A0(?) | 110
Kolom | Nee | 33.3 | +3.000 | +4.352 | F/M-N | A0(?) | 140
Windverband | Nee | 25.8 | +3.055 | +6.408 | E-F/2 | A-20(?) | 8
Windverband | Nee | 26.8 | +2.912 | +6.363 | E-F/2 | A-20(?) | 8
Windverband | Nee | 20 | +2.901 | +2.939 | E-F/1-2 | A0(?) | 8
Windverband | Nee | 20.9 | +2.901 | +2.939 | E-F/1-2 | A0(?) | 8
Kolom | Nee | 59.6 | +2.972 | +5.388 | C-D/1-2 | A0(?) | 140
Kolom | Nee | 56 | -0.250 | +1.938 | E-F/5-6 | A0(?) | 140
Kolom | Nee | 145.3 | -0.050 | +5.470 | G-H/3 | A0(?) | 240
Kolom | Nee | 83.1 | -0.050 | +3.105 | E-F/1 | A0(?) | 220
Kolom | Nee | 160.3 | -0.050 | +6.235 | D-E/1 | A0(?) | 220
Kolom | Nee | 160.3 | -0.050 | +6.235 | E-F/1 | A0(?) | 220
Kolom | Nee | 76 | -0.050 | +5.220 | C-D/1-2 | A0(?) | 220
Kolom | Nee | 72.9 | -0.050 | +2.829 | C-D/1-2 | A0(?) | 140
Kolom | Nee | 133.9 | -0.050 | +5.304 | B-C/1-2 | A0(?) | 140
Kolom | Nee | 58.1 | -0.050 | +3.883 | B-C/1-2 | A0(?) | 220
Kolom | Nee | 144.4 | -0.050 | +5.431 | I/1-2 | A0(?) | 240
Kolom | Nee | 79.8 | -0.050 | +3.108 | C-D/1 | A0(?) | 140
Kolom | Nee | 48.2 | -0.070 | +3.124 | C-D/1 | A0(?) | 220
DUMMY | Ondersteuning | 0 | +0.000 | +0.100 | F/P | DUM0(?) | 10
Windverband | Nee | 23.5 | +4.262 | +4.322 | E-F/N-P | A0(?) | 60
2 x Windverband | Nee | 23.5 | +4.262 | +4.322 | E-F/L-N | A0(?) | 60
Windverband | Nee | 25.4 | +4.262 | +4.322 | E-F/2-L | A0(?) | 60
Windverband | Nee | 23.3 | +4.262 | +4.322 | E-F/M-P | A0(?) | 60
Windverband | Nee | 24.7 | +4.262 | +4.322 | E-F/2-L | A0(?) | 60
Windverband | Nee | 22.9 | +4.262 | +4.322 | E-F/P-S | A0(?) | 60
2 x Windverband | Nee | 23.5 | +4.262 | +4.322 | E-F/R-T | A0(?) | 60
2 x Windverband | Nee | 24.7 | +4.262 | +4.322 | E-F/T-5 | A0(?) | 60
2 x Koppelkoker | Nee | 20 | +4.242 | +4.322 | E-F/N-P | A0(?) | 80
Koppelkoker | Nee | 23.1 | +4.202 | +4.322 | E-F/T-5 | A0(?) | 80
2 x Koppelkoker | Nee | 21.6 | +4.242 | +4.322 | E-F/2-L | A0(?) | 80
2 x Koppelkoker | Nee | 21.7 | +4.242 | +4.322 | E-F/L-N | A0(?) | 80
2 x Koppelkoker | Nee | 20 | +4.242 | +4.322 | E-F/P-R | A0(?) | 80
2 x Koppelkoker | Nee | 21.1 | +4.242 | +4.322 | E-F/R-T | A0(?) | 80
Ligger | Nee | 165.4 | +2.916 | +3.142 | V-G/T-5 | A0(?) | 220
Ligger | Nee | 53.7 | +2.922 | +3.142 | K-G/T-5 | A0(?) | 110
Windverband | Nee | 19.1 | +5.152 | +6.164 | D-F/1-2 | A-20(?) | 60
Windverband | Nee | 22.7 | +4.948 | +6.163 | D-F/1-2 | A-20(?) | 60
Windverband | Nee | 22.5 | +4.949 | +6.164 | C-E/1-2 | A-20(?) | 60
Windverband | Nee | 22.7 | +4.948 | +6.163 | C-E/1-2 | A-20(?) | 60
Koppelkoker | Nee | 15 | +4.994 | +5.094 | C-E/1-2 | A-20(?) | 80
Kolom | Nee | 41.9 | +3.056 | +4.757 | C-D/1-2 | A0(?) | 140
Kolom | Nee | 43.8 | +2.977 | +4.753 | C-D/1-2 | A0(?) | 140
Kolom | Nee | 41.9 | +3.052 | +4.753 | C-D/1-2 | A0(?) | 140
Windverband | Nee | 25.1 | +5.245 | +6.174 | B-D/1-2 | A-20(?) | 60
Windverband | Nee | 25.1 | +5.244 | +6.173 | B-D/1-2 | A-20(?) | 60
Windverband | Nee | 29.1 | +3.854 | +5.303 | C-D/1-2 | A-20(?) | 60
Koppelkoker | Nee | 35.9 | +4.751 | +5.412 | C-D/1-2 | A-20(?) | 80
Koppelkoker | Nee | 21.4 | +5.316 | +5.417 | C-D/1-2 | A-20(?) | 80
Kolom | Nee | 105.2 | -0.050 | +4.219 | E/2 | A0(?) | 140
2 x Kolom | Nee | 85.6 | -0.050 | +6.343 | D-E/2 | A0(?) | 139.7
Ligger | Nee | 165.4 | +2.916 | +3.142 | V-G/2-L | A0(?) | 220
Kolom | Nee | 72 | -0.050 | +2.870 | D/2 | A0(?) | 140
Windverband | Nee | 27 | +2.836 | +2.909 | C-D/1-2 | A0(?) | 8
Windverband | Nee | 27.1 | +2.836 | +2.909 | C-D/1-2 | A0(?) | 8
Windverband | Nee | 27 | +2.954 | +6.402 | C-D/2 | A-20(?) | 8
Windverband | Nee | 27.2 | +2.811 | +6.357 | C-D/2 | A-20(?) | 8
Windverband | Nee | 26.1 | +2.886 | +6.401 | B-D/2 | A-20(?) | 8
Windverband | Nee | 24.9 | +2.885 | +6.051 | B-D/2 | A-20(?) | 8
Koppelkoker | Nee | 14.3 | +5.356 | +5.993 | A-B/T-5 | A-20(?) | 80
Koppelkoker | Nee | 16.8 | +5.355 | +5.993 | A-B/T-5 | A-20(?) | 80
Windverband | Nee | 14.1 | +4.253 | +5.990 | E/3-N | A0(?) | 80
Windverband | Nee | 17 | +4.255 | +6.002 | E/M-P | A0(?) | 80
Windverband | Nee | 13.4 | +3.042 | +4.262 | F/M-N | A0(?) | 110
Windverband | Nee | 33.3 | +3.018 | +4.301 | F/M-P | A0(?) | 110
Windverband | Nee | 22.9 | -0.100 | +3.032 | F/M-P | A0(?) | 8
Windverband | Nee | 22.9 | -0.100 | +3.031 | F/M-P | A0(?) | 8
Windverband | Nee | 24.5 | -0.088 | +4.282 | E/3-N | A0(?) | 8
Ligger | Nee | 28.3 | +4.219 | +4.352 | E-F/T-5 | A0(?) | 140
Ligger | Nee | 82.2 | +3.009 | +3.142 | E-F/1-2 | A0(?) | 140
Ligger | Nee | 97.8 | +3.009 | +3.142 | E-F/1-2 | A0(?) | 140
2 x Windverband | Nee | 22.1 | -0.080 | +2.908 | B/5-6 | A0(?) | 80
Ligger | Nee | 51.5 | +4.219 | +4.352 | E/3-N | A0(?) | 140
Ligger | Nee | 75.6 | +4.219 | +4.352 | E/2-L | A0(?) | 140
Koppelkoker | Nee | 24.2 | +4.089 | +4.308 | K-G/1-2 | A-20(?) | 80
Koppelkoker | Nee | 32.4 | +5.352 | +5.432 | A-B/T-5 | A-20(?) | 80
Koppelkoker | Nee | 32.4 | +5.352 | +5.432 | A-B/T-6 | A-20(?) | 80
Koppelkoker | Nee | 32.4 | +3.995 | +4.075 | A-B/T-5 | A-20(?) | 80
Ligger | Nee | 422.8 | +2.793 | +6.172 | A-B/T-5 | A-20(?) | 150
Windverband | Nee | 10.2 | +3.031 | +4.352 | E-F/T-5 | A0(?) | 8
Windverband | Nee | 10.2 | +3.031 | +4.351 | E-F/T-5 | A0(?) | 8
2 x Windverband | Nee | 18.6 | -0.091 | +3.084 | E-F/5-6 | A0(?) | 8
Windverband | Nee | 17.7 | -0.088 | +3.081 | E-F/T-5 | A0(?) | 8
Windverband | Nee | 17.7 | -0.088 | +3.080 | E-F/T-5 | A0(?) | 8
Windverband | Nee | 21.4 | -0.097 | +3.080 | E/T-6 | A0(?) | 8
Windverband | Nee | 21.4 | -0.098 | +3.040 | E/T-6 | A0(?) | 8
Ligger | Nee | 88.4 | +3.009 | +3.142 | E-F/5-6 | A0(?) | 140
Ligger | Nee | 78.5 | +3.009 | +3.142 | E-F/5-6 | A0(?) | 140
Ligger | Nee | 70.2 | +3.009 | +3.142 | E-F/T-6 | A0(?) | 140
Ligger | Nee | 81.3 | +3.009 | +3.142 | E-F/T-5 | A0(?) | 140
Ligger | Nee | 209.7 | +2.922 | +3.142 | E-F/T-5 | A0(?) | 110
Ligger | Nee | 85.2 | +2.922 | +3.142 | E-F/5-6 | A0(?) | 110
Ligger | Nee | 209.7 | +2.922 | +3.142 | E-F/5-6 | A0(?) | 110
2 x Windverband | Nee | 18 | +3.053 | +5.539 | I-U/T-5 | A-20(?) | 8
2 x Windverband | Nee | 18 | +3.053 | +5.539 | K-G/T-5 | A-20(?) | 8
2 x Windverband | Nee | 18 | +3.053 | +5.539 | G-H/R-T | A-20(?) | 8
2 x Windverband | Nee | 15.1 | +3.059 | +5.534 | G-H/P-Q | A-20(?) | 8
2 x Windverband | Nee | 15.1 | +3.059 | +5.534 | G-H/O-P | A-20(?) | 8
2 x Windverband | Nee | 18 | +3.053 | +5.539 | G-H/3-N | A0(?) | 8
2 x Windverband | Nee | 18 | +3.053 | +5.539 | K-G/2-L | A0(?) | 8
Kolom | Nee | 109 | -0.070 | +4.352 | E-F/R-S | A0(?) | 140
Windverband | Nee | 26.5 | -0.093 | +4.286 | E/M-P | A0(?) | 8
2 x Windverband | Nee | 40.4 | -0.076 | +6.096 | D/3-P | A0(?) | 8
Ligger | Nee | 19.1 | +4.219 | +4.352 | E/L-3 | A0(?) | 140
Ligger | Nee | 69.2 | +4.219 | +4.352 | E/N-P | A0(?) | 140
Windverband | Nee | 28.7 | +3.019 | +4.291 | F/L-N | A0(?) | 110
Ligger | Nee | 69.6 | +4.219 | +4.352 | E-F/P-R | A0(?) | 140
Ligger | Nee | 321.3 | +4.022 | +4.352 | E-F/R-5 | A0(?) | 160
Ligger | Nee | 127.6 | +4.192 | +4.352 | F/R-T | A0(?) | 160
Ligger | Nee | 142.7 | +4.192 | +4.352 | F/M-P | A0(?) | 160
Ligger | Nee | 120.5 | +4.192 | +4.352 | F/P-R | A0(?) | 160
Ligger | Nee | 108.4 | +4.192 | +4.352 | F/L-N | A0(?) | 160
Ligger | Nee | 138.5 | +4.192 | +4.352 | F/T-5 | A0(?) | 160
Koppelkoker | Nee | 23.3 | +4.242 | +4.322 | E-F/T-5 | A0(?) | 80
Ligger | Nee | 196.7 | +4.219 | +4.352 | E-F/T-5 | A0(?) | 140
Windverband | Nee | 33.6 | +3.013 | +4.306 | F/2-L | A0(?) | 110
Windverband | Nee | 34.2 | +3.017 | +4.316 | F/T-5 | A0(?) | 110
Windverband | Nee | 28.6 | +3.015 | +4.289 | F/R-T | A0(?) | 110
Ligger | Nee | 112.3 | +3.009 | +3.142 | F-U/P | A0(?) | 140
Ligger | Nee | 208.6 | +2.872 | +3.142 | F/R-5 | A0(?) | 135
Ligger | Nee | 119.9 | +2.872 | +3.142 | F/P-S | A0(?) | 135
Ligger | Nee | 119.9 | +2.872 | +3.142 | F/M-P | A0(?) | 135
Ligger | Nee | 208.6 | +2.872 | +3.142 | F/2-N | A0(?) | 135
Ligger | Nee | 53 | +2.922 | +3.142 | E-F/T-5 | A0(?) | 110
Ligger | Nee | 112.5 | +2.922 | +3.142 | E-F/T-5 | A0(?) | 110
Ligger | Nee | 35.7 | +2.922 | +3.142 | E-F/T-5 | A0(?) | 110
Ligger | Nee | 459.6 | +4.022 | +4.352 | E-F/P | A0(?) | 160
Windverband | Nee | 23.3 | +4.262 | +4.322 | E-F/P-S | A0(?) | 60
Ligger | Nee | 460.4 | +4.022 | +4.352 | E-F/L | A0(?) | 160
Ligger | Nee | 447.6 | +4.022 | +4.352 | E-F/T | A0(?) | 160
Ligger | Nee | 455.5 | +4.022 | +4.352 | E-F/R-S | A0(?) | 160
Ligger | Nee | 460.4 | +4.022 | +4.352 | E-F/M-N | A0(?) | 160
Koppelkoker | Nee | 30.5 | +5.950 | +6.030 | D-E/2-3 | A0(?) | 80
Ligger | Nee | 94.9 | +2.922 | +3.142 | E-F/T-6 | A0(?) | 110
Ligger | Nee | 72.1 | +2.922 | +3.142 | E-F/5-6 | A0(?) | 110
Ligger | Nee | 56 | +2.922 | +3.142 | E-F/T-5 | A0(?) | 110
Ligger | Nee | 59.7 | +3.019 | +3.152 | G/N-P | A0(?) | 140
Ligger | Nee | 63.5 | +3.019 | +3.152 | G/P-R | A0(?) | 140
Ligger | Nee | 588.3 | +2.902 | +3.142 | V-H/4-S | A0(?) | 240
Ligger | Nee | 588.5 | +2.902 | +3.142 | V-H/M-O | A0(?) | 240
Ligger | Nee | 35.9 | +3.009 | +3.142 | G-H/M-O | A0(?) | 140
Ligger | Nee | 36 | +3.009 | +3.142 | G-H/Q-S | A0(?) | 140
Ligger | Nee | 64.7 | +3.009 | +3.142 | V-G/1-2 | A0(?) | 140
Ligger | Nee | 64.7 | +3.009 | +3.142 | K-G/2-L | A0(?) | 140
Ligger | Nee | 64.7 | +3.009 | +3.142 | G-H/2-3 | A0(?) | 140
Ligger | Nee | 64.7 | +3.009 | +3.142 | G-H/3-N | A0(?) | 140
Ligger | Nee | 43.5 | +3.009 | +3.142 | G-H/O-P | A0(?) | 140
Ligger | Nee | 43.5 | +3.009 | +3.142 | G-H/P-Q | A0(?) | 140
Ligger | Nee | 64.7 | +3.009 | +3.142 | G-H/R-T | A0(?) | 140
Ligger | Nee | 78.8 | +3.009 | +3.142 | E-I/T-5 | A0(?) | 140
Ligger | Nee | 64.7 | +3.009 | +3.142 | I-U/T-5 | A0(?) | 140
Ligger | Nee | 64.7 | +3.009 | +3.142 | V-G/T-5 | A0(?) | 140
Ligger | Nee | 64.7 | +3.009 | +3.142 | K-G/T-5 | A0(?) | 140
Ligger | Nee | 64.7 | +3.009 | +3.142 | G-H/S-5 | A0(?) | 140
Ligger | Nee | 600.6 | +2.902 | +3.142 | V-H/P | A0(?) | 240
Ligger | Nee | 1317.7 | +2.912 | +3.142 | V-U/1-5 | A0(?) | 240
Ligger | Nee | 280.3 | +2.912 | +3.142 | F-U/T-5 | A0(?) | 240
Ligger | Nee | 57.2 | +2.932 | +3.152 | W-I/T-5 | A0(?) | 110
Ligger | Nee | 403.7 | +2.922 | +3.142 | V-G/S-5 | A0(?) | 220
Ligger | Nee | 446.2 | +2.922 | +3.142 | V-H/R-T | A0(?) | 220
Ligger | Nee | 53.7 | +2.922 | +3.142 | K-G/2-L | A0(?) | 110
Ligger | Nee | 446 | +2.922 | +3.142 | V-H/3-N | A0(?) | 220
Ligger | Nee | 403.7 | +2.922 | +3.142 | V-G/2-M | A0(?) | 220
Kokerpligger | Nee | 83.1 | +0.628 | +2.860 | E-F/5-6> | A0(?) | 100
Koppelkoker | Nee | 30.3 | +5.950 | +6.030 | D-E/2-3 | A0(?) | 80
Ligger | Nee | 53.1 | +5.937 | +6.070 | C-E/2 | A0(?) | 140
Ligger | Nee | 53.1 | +5.937 | +6.070 | D-F/2 | A0(?) | 140
Windverband | Nee | 24.6 | -0.081 | +3.103 | E-F/T-6 | A0(?) | 8
Windverband | Nee | 24.5 | -0.081 | +3.073 | E-F/T-6 | A0(?) | 8
Windverband | Nee | 24.5 | -0.080 | +3.166 | K-G/5-6 | A0(?) | 8
Windverband | Nee | 28.5 | -0.076 | +4.311 | K-G/5-6 | A0(?) | 8
Windverband | Nee | 24.2 | -0.080 | +3.113 | G-H/T-5 | A0(?) | 8
Windverband | Nee | 28.3 | -0.076 | +4.258 | G-H/T-5 | A0(?) | 8
Windverband | Nee | 24.5 | -0.081 | +3.113 | G-H/S-T | A0(?) | 8
Windverband | Nee | 28.5 | -0.076 | +4.258 | G-H/S-T | A0(?) | 8
Windverband | Nee | 24.5 | -0.081 | +3.113 | G-H/R | A0(?) | 8
Windverband | Nee | 28.5 | -0.076 | +4.258 | G-H/R | A0(?) | 8
Windverband | Nee | 24.5 | -0.081 | +3.113 | G-H/N | A0(?) | 8
Windverband | Nee | 28.5 | -0.076 | +4.258 | G-H/N | A0(?) | 8
Windverband | Nee | 24.5 | -0.081 | +3.113 | G-H/3-M | A0(?) | 8
Windverband | Nee | 28.5 | -0.076 | +4.258 | G-H/3-M | A0(?) | 8
Windverband | Nee | 24.2 | -0.080 | +3.113 | K-G/1-2 | A0(?) | 8
Windverband | Nee | 28.3 | -0.076 | +4.258 | K-G/1-2 | A0(?) | 8
Windverband | Nee | 20.3 | +5.302 | +6.113 | E-I/T-5 | A-20(?) | 60
Windverband | Nee | 19.8 | +5.369 | +6.131 | E-I/T-5 | A-20(?) | 60
Windverband | Nee | 31.9 | +2.782 | +4.240 | E-J/5-6 | A-10(?) | 60
Windverband | Nee | 31.4 | +2.790 | +4.233 | I-G/5-6 | A-10(?) | 60
Windverband | Nee | 25.4 | +4.175 | +5.494 | I-U/T-6 | A-20(?) | 60
Windverband | Nee | 27 | +4.182 | +5.361 | E-J/T-6 | A-20(?) | 60
Windverband | Nee | 18.1 | +5.510 | +6.258 | V-K/T-5 | A-20(?) | 60
Windverband | Nee | 16.8 | +5.537 | +6.249 | V-G/T-5 | A-20(?) | 60
Windverband | Nee | 31.6 | +2.790 | +4.279 | K-G/T-6 | A-10(?) | 60
Windverband | Nee | 31.4 | +2.774 | +4.279 | G-H/T-5 | A-10(?) | 60
Windverband | Nee | 24.9 | +4.220 | +5.377 | G/T-5 | A-20(?) | 60
Windverband | Nee | 25.2 | +4.222 | +5.508 | V-G/T-5 | A-20(?) | 60
Windverband | Nee | 17.7 | +5.319 | +6.201 | K-G/S-5 | A-20(?) | 60
Windverband | Nee | 16.4 | +5.425 | +6.251 | K-H/S-T | A-20(?) | 60
Windverband | Nee | 31.4 | +2.768 | +4.269 | G-H/T-5 | A-10(?) | 60
Windverband | Nee | 31.4 | +2.763 | +4.264 | G-H/S-5 | A-10(?) | 60
Windverband | Nee | 25.2 | +4.207 | +5.369 | G-H/R-5 | A0(?) | 60
Windverband | Nee | 25.2 | +4.210 | +5.377 | G-H/T-5 | A-20(?) | 60
Windverband | Nee | 15.3 | +5.306 | +6.065 | G-H/P-Q | A-20(?) | 60
Windverband | Nee | 15.3 | +5.271 | +6.112 | G-H/P-Q | A-20(?) | 60
Ligger | Nee | 68.6 | +5.352 | +6.371 | G-H/O | A-20(?) | 110
Ligger | Nee | 296.4 | +2.836 | +5.636 | G-H/M-O | A-20(?) | 135
Windverband | Nee | 15.3 | +5.294 | +6.064 | G-H/O-P | A-20(?) | 60
Windverband | Nee | 15.1 | +5.271 | +6.107 | G-H/O-P | A-20(?) | 60
Windverband | Nee | 26.5 | +2.778 | +4.137 | G-H/M-P | A-10(?) | 60
Windverband | Nee | 26.3 | +2.813 | +4.137 | G-H/P-S | A-10(?) | 60
Windverband | Nee | 23.5 | +4.080 | +5.364 | G-H/P-Q | A-20(?) | 60
Windverband | Nee | 23.5 | +4.074 | +5.376 | G-H/O-P | A-20(?) | 60
Koppelkoker | Nee | 17.7 | +5.408 | +5.565 | I-U/T-5 | A-20(?) | 80
Koppelkoker | Nee | 17.7 | +5.385 | +5.583 | V-G/T-5 | A-20(?) | 80
Koppelkoker | Nee | 17.7 | +5.387 | +5.585 | K-G/T-5 | A-20(?) | 80
Koppelkoker | Nee | 17.7 | +5.382 | +5.588 | G-H/S-5 | A-20(?) | 80
Koppelkoker | Nee | 17.7 | +5.373 | +5.588 | G-H/R-T | A-20(?) | 80
Koppelkoker | Nee | 15.7 | +4.097 | +4.223 | G-H/N-P | A-20(?) | 80
Koppelkoker | Nee | 15.7 | +4.125 | +4.226 | G-H/P-R | A-20(?) | 80
Koppelkoker | Nee | 12.9 | +4.097 | +4.229 | G-H/R-S | A-20(?) | 80
Koppelkoker | Nee | 24 | +4.101 | +4.351 | G-H/S-5 | A-20(?) | 80
Koppelkoker | Nee | 24 | +4.142 | +4.356 | G-H/T-5 | A-20(?) | 80
Koppelkoker | Nee | 24 | +4.141 | +4.367 | G-H/T-5 | A-20(?) | 80
Koppelkoker | Nee | 23.8 | +4.157 | +4.366 | K-G/T-5 | A-20(?) | 80
Koppelkoker | Nee | 23.8 | +4.157 | +4.321 | I-G/5-6 | A-20(?) | 80
Koppelkoker | Nee | 26.3 | +4.132 | +4.327 | E-J/5-6 | A-20(?) | 80
Koppelkoker | Nee | 21.7 | +5.371 | +5.539 | E-I/T-5 | A-20(?) | 80
Koppelkoker | Nee | 9.4 | +5.369 | +5.474 | G-H/Q-S | A-20(?) | 80
Koppelkoker | Nee | 11.5 | +5.333 | +5.468 | G-H/P-Q | A-20(?) | 80
Koppelkoker | Nee | 11.5 | +5.333 | +5.457 | G-H/O-P | A-20(?) | 80
Ligger | Nee | 106.1 | +2.837 | +2.970 | E-J/5-6 | A-10(?) | 140
Ligger | Nee | 104.7 | +2.837 | +2.970 | J-G/5-6 | A-10(?) | 140
Ligger | Nee | 104.7 | +2.837 | +2.970 | K-H/5-6 | A-10(?) | 140
Ligger | Nee | 104.7 | +2.837 | +2.970 | G-H/T-6 | A-10(?) | 140
Ligger | Nee | 104.7 | +2.837 | +2.970 | G-H/T-5 | A-10(?) | 140
Ligger | Nee | 104.7 | +2.837 | +2.970 | G-H/S-5 | A-10(?) | 140
Ligger | Nee | 33.8 | +3.053 | +3.153 | G-H/R-T | A-10(?) | 100
Ligger | Nee | 68.6 | +2.837 | +2.970 | H/P-R | A-10(?) | 140
Ligger | Nee | 68.6 | +2.837 | +2.970 | H/N-P | A-10(?) | 140
Ligger | Nee | 33.7 | +3.053 | +3.153 | G-H/3-N | A-10(?) | 100
Ligger | Nee | 66.9 | +6.169 | +6.302 | E-W/T-5 | A-20(?) | 140
Ligger | Nee | 49.3 | +6.169 | +6.302 | I-V/T-5 | A-20(?) | 140
Ligger | Nee | 50.8 | +6.169 | +6.302 | V-K/T-5 | A-20(?) | 140
Ligger | Nee | 49.3 | +6.169 | +6.302 | K-G/T-5 | A-20(?) | 140
Ligger | Nee | 49.3 | +6.169 | +6.302 | K-G/S-T | A-20(?) | 140
Ligger | Nee | 49.2 | +6.169 | +6.302 | K-G/R-S | A-20(?) | 140
Ligger | Nee | 25.4 | +6.169 | +6.302 | G/Q-R | A-20(?) | 140
Ligger | Nee | 31.6 | +6.169 | +6.302 | G/P-4 | A-20(?) | 140
Ligger | Nee | 31.6 | +6.169 | +6.302 | G/O-P | A-20(?) | 140
Ligger | Nee | 65 | +5.368 | +6.343 | G-H/M-N | A-20(?) | 110
Ligger | Nee | 298.2 | +2.837 | +5.652 | G-H/3-N | A-20(?) | 135
Ligger | Nee | 298.5 | +2.821 | +5.653 | G-H/R-T | A-20(?) | 135
Ligger | Nee | 65 | +5.329 | +6.301 | G-H/P | A-20(?) | 110
Ligger | Nee | 68.6 | +5.364 | +6.376 | G-H/Q | A-20(?) | 110
Ligger | Nee | 65 | +5.369 | +6.348 | G-H/R-S | A-20(?) | 110
Ligger | Nee | 262.5 | +2.782 | +6.250 | E-F/T-6 | A-20(?) | 140
Ligger | Nee | 58.9 | +5.436 | +6.344 | W-I/T-5 | A-20(?) | 110
Ligger | Nee | 64.5 | +5.378 | +6.342 | K-G/T-5 | A-20(?) | 110
Ligger | Nee | 296.1 | +2.871 | +5.648 | G-H/Q-S | A-20(?) | 135
Ligger | Nee | 298.2 | +2.809 | +5.613 | G-H/P | A-20(?) | 135
Ligger | Nee | 297.9 | +2.872 | +5.661 | G-H/T-5 | A-20(?) | 135
Ligger | Nee | 306.5 | +2.814 | +5.720 | I-J/T-6 | A-20(?) | 135
Ligger | Nee | 56 | +5.470 | +6.342 | K-H/3-M | A-20(?) | 110
2 x Windverband | Nee | 18 | +3.053 | +5.539 | I-U/1-2 | A-20(?) | 8
Koppelkoker | Nee | 16 | +5.002 | +5.316 | D-F/1-2 | A-20(?) | 80
Ligger | Nee | 56 | +5.471 | +6.343 | K-G/2-L | A-20(?) | 110
Windverband | Nee | 28.7 | +4.102 | +5.402 | E-J/1-2 | A-20(?) | 60
Windverband | Nee | 19.5 | +5.343 | +6.113 | E-I/1-2 | A-20(?) | 60
Windverband | Nee | 19.8 | +5.372 | +6.113 | E-I/1-2 | A-20(?) | 60
Ligger | Nee | 104.7 | +2.837 | +2.970 | J-G/1-2 | A-10(?) | 140
Windverband | Nee | 17.7 | +5.315 | +6.201 | K-G/2-M | A-20(?) | 60
Windverband | Nee | 16.3 | +5.412 | +6.192 | K-H/L-3 | A-20(?) | 60
Windverband | Nee | 42.4 | +2.745 | +4.213 | G-H/1-L | A-10(?) | 70
Windverband | Nee | 42.1 | +2.766 | +4.219 | G-H/2-3 | A-10(?) | 70
Windverband | Nee | 34.8 | +4.154 | +5.368 | G-H/2-N | A-20(?) | 70
Windverband | Nee | 35 | +4.139 | +5.373 | G-H/2-L | A-20(?) | 70
Windverband | Nee | 17.7 | +5.316 | +6.202 | V-K/1-L | A-20(?) | 60
Windverband | Nee | 16.4 | +5.413 | +6.231 | V-G/2-L | A-20(?) | 60
Windverband | Nee | 30.5 | +2.776 | +4.162 | I-G/1-2 | A-10(?) | 60
Windverband | Nee | 30.5 | +2.789 | +4.160 | E-J/1-2 | A-10(?) | 60
Windverband | Nee | 26.5 | +4.109 | +5.374 | I-U/1-2 | A-20(?) | 60
Windverband | Nee | 34.8 | +4.152 | +5.373 | G/1-L | A-20(?) | 70
Windverband | Nee | 42.4 | +2.745 | +4.220 | G-H/1-2 | A-10(?) | 70
Windverband | Nee | 42.4 | +2.766 | +4.220 | K-G/1-2 | A-10(?) | 70
Windverband | Nee | 34.8 | +4.147 | +5.374 | V-G/1-2 | A-20(?) | 70
Koppelkoker | Nee | 26.6 | +3.955 | +4.249 | E-J/1-2 | A-20(?) | 80
Koppelkoker | Nee | 24.2 | +4.087 | +4.250 | I-G/1-2 | A-20(?) | 80
Koppelkoker | Nee | 24.2 | +4.089 | +4.308 | G-H/1-2 | A-20(?) | 80
Koppelkoker | Nee | 24.1 | +4.094 | +4.298 | G-H/1-L | A-20(?) | 80
Koppelkoker | Nee | 24.2 | +4.095 | +4.305 | G-H/2-M | A-20(?) | 80
Koppelkoker | Nee | 12.9 | +4.092 | +4.195 | G-H/M-N | A-20(?) | 80
Ligger | Nee | 96.9 | +2.837 | +2.970 | E-F/1 | A-10(?) | 140
Ligger | Nee | 82.5 | +2.837 | +2.970 | E-F/1 | A-10(?) | 140
Ligger | Nee | 104.7 | +2.837 | +2.970 | E-J/1-2 | A-10(?) | 140
Ligger | Nee | 104.7 | +2.837 | +2.970 | G-H/2-3 | A-10(?) | 140
2 x Ligger | Nee | 104.7 | +2.837 | +2.970 | G-H/1-2 | A-10(?) | 140
Ligger | Nee | 104.7 | +2.837 | +2.970 | K-H/1-2 | A-10(?) | 140
Ligger | Nee | 25.4 | +6.169 | +6.302 | G/N-O | A-20(?) | 140
Ligger | Nee | 49.2 | +6.169 | +6.302 | K-G/M-N | A-20(?) | 140
Ligger | Nee | 49.3 | +6.169 | +6.302 | K-G/L-M | A-20(?) | 140
Ligger | Nee | 49.3 | +6.169 | +6.302 | K-G/2-L | A-20(?) | 140
Ligger | Nee | 49.3 | +6.169 | +6.302 | V-K/2-L | A-20(?) | 140
Koppelkoker | Nee | 17.7 | +5.373 | +5.575 | G-H/3-N | A-20(?) | 80
Koppelkoker | Nee | 17.7 | +5.382 | +5.578 | V-G/1-2 | A-20(?) | 80
Koppelkoker | Nee | 17.7 | +5.382 | +5.578 | K-G/2-L | A-20(?) | 80
Koppelkoker | Nee | 17.7 | +5.379 | +5.575 | G-H/2-3 | A-20(?) | 80
Koppelkoker | Nee | 9.4 | +5.356 | +5.473 | G-H/M-O | A-20(?) | 80
Ligger | Nee | 65.9 | +5.357 | +6.345 | K-G/2-L | A-20(?) | 110
Ligger | Nee | 310.2 | +2.830 | +5.754 | G-H/2-3 | A-20(?) | 135
Ligger | Nee | 298.5 | +2.834 | +5.657 | G-H/1-L | A-20(?) | 135
Ligger | Nee | 310.2 | +2.830 | +5.755 | K-H/1-2 | A-20(?) | 135
Ligger | Nee | 65.9 | +5.357 | +6.345 | V-U/1-L | A-20(?) | 110
Ligger | Nee | 21.2 | +4.219 | +4.352 | E-F/2 | A0(?) | 140
Ligger | Nee | 95.7 | +4.219 | +4.352 | E-F/2 | A0(?) | 140
Ligger | Nee | 82.5 | +4.219 | +4.352 | E-F/2 | A0(?) | 140
Ligger | Nee | 136.2 | +4.192 | +4.352 | F/2-L | A0(?) | 160
Ligger | Nee | 82.5 | +6.169 | +6.302 | E-F/2 | A-20(?) | 140
Ligger | Nee | 96.9 | +6.169 | +6.302 | E-F/2 | A-20(?) | 140
Ligger | Nee | 22.9 | +4.219 | +4.352 | E-F/2 | A0(?) | 140
Koppelkoker | Nee | 28.5 | +3.947 | +4.187 | E-F/1-2 | A-20(?) | 80
Ligger | Nee | 61.2 | +5.412 | +6.344 | W-I/1-2 | A-20(?) | 110
Ligger | Nee | 77.1 | +3.009 | +3.142 | E-I/1-2 | A0(?) | 140
Ligger | Nee | 64.7 | +3.009 | +3.142 | I-U/1-2 | A0(?) | 140
Windverband | Nee | 27 | +5.148 | +6.293 | E-F/1-2 | A-20(?) | 60
Windverband | Nee | 24.7 | +5.343 | +6.272 | E-F/1-2 | A-20(?) | 60
Windverband | Nee | 31.3 | +3.901 | +5.402 | E-F/1-2 | A-20(?) | 60
Windverband | Nee | 28.1 | +2.836 | +3.946 | E-F/1-2 | A-10(?) | 60
Windverband | Nee | 26.3 | +2.780 | +3.960 | E-F/1-2 | A-10(?) | 60
Windverband | Nee | 30.7 | +3.904 | +5.207 | E-F/1-2 | A-20(?) | 60
Koppelkoker | Nee | 28.6 | +5.223 | +5.519 | E-F/1-2 | A-20(?) | 80
Koppelkoker | Nee | 24.1 | +5.381 | +5.519 | E-F/1-2 | A-20(?) | 80
Koppelkoker | Nee | 30.5 | +3.946 | +4.532 | E-F/1-2 | A-20(?) | 80
Koppelkoker | Nee | 24.1 | +3.947 | +4.048 | E-F/1-2 | A-20(?) | 80
Ligger | Nee | 59.6 | +2.922 | +3.142 | W-I/1-2 | A0(?) | 110
Ligger | Nee | 281.1 | +2.912 | +3.142 | F-U/2-L | A0(?) | 240
Koppelkoker | Nee | 17.7 | +5.378 | +5.536 | I-U/1-2 | A-20(?) | 80
Ligger | Nee | 65.5 | +6.169 | +6.302 | E-W/2 | A-20(?) | 140
Ligger | Nee | 49.3 | +6.169 | +6.302 | I-V/2-L | A-20(?) | 140
Koppelkoker | Nee | 21.2 | +5.418 | +5.548 | E-I/1-2 | A-20(?) | 80
Ligger | Nee | 298.5 | +2.834 | +5.658 | V-G/1-2 | A-20(?) | 135
Ligger | Nee | 305.4 | +2.831 | +5.715 | I-J/1-2 | A-20(?) | 135
2 x Ligger | Nee | 280.4 | +2.831 | +6.345 | E-F/1-2 | A-20(?) | 110
2 x Windverband | Nee | 15.1 | +3.048 | +4.645 | E-F/1-2 | A-20(?) | 8
2 x Windverband | Nee | 18 | +3.053 | +5.539 | E-F/1-2 | A-20(?) | 8
4 x Windverband | Nee | 20.5 | -0.076 | +3.108 | E-F/1-2 | A0(?) | 8
Koppelkoker | Nee | 23.6 | +3.168 | +3.269 | E-F/1-2 | A0(?) | 80
2 x Windverband | Nee | 21.2 | +3.049 | +5.543 | E-F/1-2 | A-20(?) | 8
2 x Windverband | Nee | 23.6 | -0.080 | +3.112 | E-F/1-2 | A0(?) | 8
Ligger | Nee | 114.5 | +3.009 | +3.142 | E-F/1-2 | A0(?) | 140
Ligger | Nee | 114.9 | +3.009 | +3.142 | E-F/1-2 | A0(?) | 140
2 x Koppelkoker | Nee | 12.9 | +2.782 | +3.160 | E-F/1-2 | A0(?) | 80
2 x Koppelkoker | Nee | 22.2 | +2.782 | +2.862 | E-F/1-2 | A0(?) | 80
Ligger | Nee | 82.5 | +3.009 | +3.142 | E-F/2 | A0(?) | 140
Ligger | Nee | 96.5 | +3.009 | +3.142 | E-F/2 | A0(?) | 140
Ligger | Nee | 149.9 | +3.009 | +3.142 | E-F/1-2 | A0(?) | 140
Koppelkoker | Nee | 20.5 | +3.182 | +3.262 | E-F/1-2 | A0(?) | 80
Ligger | Nee | 98.6 | +5.937 | +6.070 | E/2-3 | A0(?) | 140
Ligger | Nee | 123.6 | +5.937 | +6.070 | E/3-P | A0(?) | 140
Ligger | Nee | 98.4 | +5.937 | +6.070 | D/2-3 | A0(?) | 140
Ligger | Nee | 124.1 | +5.937 | +6.070 | D/3-P | A0(?) | 140
Koppelkoker | Nee | 36.2 | +6.056 | +6.136 | D-E/3-P | A0(?) | 80
Koppelkoker | Nee | 29.1 | +6.056 | +6.136 | D-E/2-3 | A0(?) | 80
Windverband | Nee | 42.1 | +6.007 | +6.125 | D-E/3-P | A0(?) | 60
Windverband | Nee | 34 | +6.007 | +6.125 | D-E/2-3 | A0(?) | 60
Windverband | Nee | 41.7 | +6.006 | +6.125 | D-E/3-P | A0(?) | 60
Windverband | Nee | 33.6 | +6.007 | +6.125 | D-E/2-3 | A0(?) | 60
Oplegging | Nee | 438.7 | +5.875 | +6.158 | D-E/4 | HH0(?) | 366.686
Ligger | Nee | 525 | +5.767 | +6.154 | D-E/P | A0(?) | 150
Ligger | Nee | 709.4 | +5.707 | +6.154 | D-E/3 | A0(?) | 170
Ligger | Nee | 415.8 | +5.788 | +6.154 | D-E/2 | A-30(?) | 150
Koppelkoker | Nee | 24.5 | +3.843 | +4.983 | D-E/1-2 | A-20(?) | 80
Koppelkoker | Nee | 24.9 | +4.953 | +6.134 | D-E/1-2 | A-20(?) | 80
Windverband | Nee | 31.9 | +3.801 | +4.906 | D-E/1-2 | A-20(?) | 60
Windverband | Nee | 32.4 | +3.795 | +4.906 | D-E/1-2 | A-20(?) | 60
Windverband | Nee | 30.6 | +2.894 | +3.796 | D-E/1-2 | A-10(?) | 60
2 x Windverband | Nee | 31.8 | +4.894 | +6.027 | D-E/1-2 | A-20(?) | 60
Windverband | Nee | 31.9 | +3.784 | +4.960 | D-E/1-2 | A-20(?) | 60
Windverband | Nee | 31.9 | +3.784 | +4.901 | D-E/1-2 | A-20(?) | 60
Windverband | Nee | 30.7 | +2.895 | +3.796 | D-E/1-2 | A-10(?) | 60
Koppelkoker | Nee | 22.6 | +2.957 | +3.874 | D-E/1-2 | A-20(?) | 80
Ligger | Nee | 414.8 | +3.753 | +4.085 | D-E/1-2 | A-20(?) | 150
Ligger | Nee | 414.8 | +4.863 | +5.195 | D-E/1-2 | A-20(?) | 150
Ligger | Nee | 53.1 | +6.163 | +6.296 | D-F/2 | A-20(?) | 140
2 x Ligger | Nee | 151 | +4.531 | +6.426 | D-E/1-2 | A-20(?) | 110
Ligger | Nee | 52.6 | +5.999 | +6.169 | D-F/1 | A-20(?) | 140
Ligger | Nee | 150.8 | +4.533 | +6.426 | E-F/1-2 | A-20(?) | 110
Ligger | Nee | 275.2 | +2.890 | +6.343 | D-E/1-2 | A-20(?) | 110
Ligger | Nee | 275.2 | +2.895 | +6.346 | E-F/1-2 | A-20(?) | 110
Ligger | Nee | 52.6 | +4.471 | +4.640 | D-F/1-2 | A-20(?) | 140
Ligger | Nee | 53.1 | +6.163 | +6.296 | C-E/2 | A-20(?) | 140
Ligger | Nee | 52.6 | +5.999 | +6.169 | C-E/1 | A-20(?) | 140
Koppelkoker | Nee | 14.8 | +2.861 | +2.937 | D-F/1 | A-10(?) | 76.1
Koppelkoker | Nee | 14.3 | +2.863 | +2.939 | C-E/1 | A-10(?) | 76.1
Ligger | Nee | 151 | +4.531 | +6.426 | C-D/1-2 | A-20(?) | 110
Ligger | Nee | 279.5 | +2.839 | +6.343 | D-E/1-2 | A-20(?) | 110
Kolom | Nee | 133.9 | -0.050 | +4.352 | E/L | A0(?) | 160
Windverband | Nee | 26.1 | -0.076 | +3.896 | A-B/T-5 | A0(?) | 80
Windverband | Nee | 22.7 | -0.081 | +2.901 | A-B/T-5 | A0(?) | 80
Windverband | Nee | 26.8 | -0.076 | +4.046 | A-B/5-6 | A0(?) | 80
Windverband | Nee | 23.5 | -0.080 | +3.050 | A-B/5-6 | A0(?) | 80
Ligger | Nee | 249.4 | +2.825 | +6.078 | A-B/5-6 | A-20(?) | 140
Ligger | Nee | 249.4 | +2.825 | +6.078 | A-B/T-5 | A-20(?) | 140
Windverband | Nee | 22.2 | +2.843 | +5.906 | B/5-6 | A-20(?) | 80
Windverband | Nee | 22.2 | +2.889 | +5.926 | B/5-6 | A-20(?) | 80
Windverband | Nee | 26.5 | +5.373 | +5.930 | A-B/T-5 | A-20(?) | 60
Windverband | Nee | 26.5 | +5.362 | +5.930 | A-B/T-6 | A-20(?) | 60
Windverband | Nee | 34 | +4.005 | +5.430 | A-B/T-5 | A-20(?) | 60
Windverband | Nee | 31.4 | +2.919 | +4.077 | A-B/T-5 | A-20(?) | 60
Windverband | Nee | 34 | +4.017 | +5.435 | A-B/T-6 | A-20(?) | 60
Windverband | Nee | 31.4 | +2.910 | +4.077 | A-B/T-6 | A-20(?) | 60
2 x Windverband | Nee | 27 | -0.048 | +2.944 | A/T-6 | A0(?) | 80
Koppelkoker | Nee | 32.4 | +3.995 | +4.075 | A-B/T-6 | A-20(?) | 80
Ligger | Nee | 41.7 | +2.841 | +2.974 | A-B/5-6 | A0(?) | 140
Ligger | Nee | 98.6 | +2.834 | +2.974 | A-B/5-6 | A0(?) | 140
Ligger | Nee | 111.6 | +2.842 | +2.975 | A/T-6 | A-20(?) | 140
Ligger | Nee | 111.6 | +2.842 | +2.975 | A/T-5 | A-20(?) | 140
Ligger | Nee | 228.2 | +5.900 | +6.033 | B/T-6 | A-20(?) | 140
Ligger | Nee | 328 | +2.803 | +2.974 | A-B/T-6 | A0(?) | 180
Ligger | Nee | 101 | +2.834 | +2.974 | A-B/T-5 | A0(?) | 140
Ligger | Nee | 62.7 | +2.803 | +2.974 | B/T-5 | A0(?) | 180
Ligger | Nee | 110.7 | +2.803 | +2.974 | B/5-6 | A0(?) | 180
Ligger | Nee | 41.8 | +2.841 | +2.974 | A-B/T-5 | A0(?) | 140
Ligger | Nee | 143.2 | +2.803 | +2.974 | B/T-5 | A0(?) | 180
Ligger | Nee | 108.7 | +2.852 | +3.052 | B/3-O | A0(?) | 75
Ligger | Nee | 58.9 | +2.852 | +3.052 | B/Q-S | A0(?) | 75
Ligger | Nee | 105.2 | +2.852 | +3.052 | B/S-5 | A0(?) | 75
Ligger | Nee | 56.2 | +2.852 | +3.052 | B/O-Q | A0(?) | 75
Windverband | Nee | 21.7 | -0.079 | +3.014 | C-D/1-2 | A0(?) | 8
Windverband | Nee | 25.9 | -0.074 | +4.094 | C-D/1-2 | A0(?) | 8
2 x Windverband | Nee | 25.8 | -0.059 | +2.973 | C-D/1-2 | A0(?) | 8
Ligger | Nee | 165.8 | +2.822 | +2.955 | C-D/1-2 | A0(?) | 140
Koppelkoker | Nee | 28.5 | +2.895 | +2.975 | C-D/1-2 | A0(?) | 80
Windverband | Nee | 24.5 | -0.113 | +2.986 | C-D/3 | A0(?) | 8
Windverband | Nee | 24.5 | -0.081 | +3.016 | C-D/3 | A0(?) | 8
Ligger | Nee | 357 | +2.842 | +3.062 | D/2-R | A0(?) | 80
Ligger | Nee | 187.5 | +2.852 | +3.052 | C-D/3-R | A0(?) | 100
Ligger | Nee | 187.2 | +2.852 | +3.052 | C-D/3-S | A0(?) | 100
Ligger | Nee | 42.7 | +2.852 | +3.052 | C-D/3 | A0(?) | 100
Ligger | Nee | 98.2 | +2.852 | +3.052 | C-D/3 | A0(?) | 100
Ligger | Nee | 284.6 | +2.852 | +3.052 | B-D/3 | A0(?) | 100
Windverband | Nee | 23.5 | +2.816 | +3.904 | C-D/1-2 | A-10(?) | 60
Koppelkoker | Nee | 33.8 | +4.750 | +4.851 | C-D/1-2 | A-20(?) | 80
Windverband | Nee | 29.5 | +3.846 | +4.762 | C-D/1-2 | A-20(?) | 60
Windverband | Nee | 35.3 | +4.704 | +6.118 | C-D/1-2 | A-20(?) | 60
Windverband | Nee | 35.3 | +4.703 | +6.119 | C-D/1-2 | A-20(?) | 60
Windverband | Nee | 27.6 | +2.774 | +3.912 | B-D/1-2 | A-10(?) | 60
Windverband | Nee | 31.4 | +2.774 | +3.905 | C-D/1-2 | A-10(?) | 60
Windverband | Nee | 28.3 | +2.810 | +3.905 | C-D/1-2 | A-10(?) | 60
Windverband | Nee | 26.3 | +3.846 | +4.758 | C-D/1-2 | A-20(?) | 60
Windverband | Nee | 31.8 | +3.854 | +5.303 | B-D/1-2 | A-20(?) | 60
Koppelkoker | Nee | 27.2 | +3.876 | +4.000 | B-D/1-2 | A-20(?) | 80
Koppelkoker | Nee | 21.4 | +3.892 | +3.993 | C-D/1-2 | A-20(?) | 80
Koppelkoker | Nee | 33.8 | +3.892 | +3.993 | C-D/1-2 | A-20(?) | 80
Koppelkoker | Nee | 28.7 | +3.892 | +3.993 | C-D/1-2 | A-20(?) | 80
Koppelkoker | Nee | 28.7 | +4.746 | +4.851 | C-D/1-2 | A-20(?) | 80
Koppelkoker | Nee | 27.2 | +5.316 | +5.417 | B-D/1-2 | A-20(?) | 80
Ligger | Nee | 100 | +6.163 | +6.296 | C-D/2 | A-20(?) | 140
Ligger | Nee | 116.9 | +6.163 | +6.296 | C-D/2 | A-20(?) | 140
Ligger | Nee | 80.7 | +6.163 | +6.296 | C-D/2 | A-20(?) | 140
Ligger | Nee | 94.2 | +6.163 | +6.296 | B-D/2 | A-20(?) | 140
Windverband | Nee | 17.2 | +2.887 | +5.259 | B-C/1-2 | A-20(?) | 8
Windverband | Nee | 20.1 | +2.891 | +6.045 | B-C/1-2 | A-20(?) | 8
Windverband | Nee | 19.3 | -0.076 | +2.874 | C-D/1-2 | A0(?) | 8
Windverband | Nee | 19.3 | -0.076 | +2.873 | C-D/1-2 | A0(?) | 8
Windverband | Nee | 28.5 | -0.084 | +2.934 | C-D/1 | A0(?) | 8
Windverband | Nee | 28.5 | -0.086 | +2.934 | C-D/1 | A0(?) | 8
2 x Windverband | Nee | 19.5 | -0.076 | +2.942 | B-C/1-2 | A0(?) | 8
Ligger | Nee | 281.1 | +2.833 | +6.355 | C-D/1-2 | A-20(?) | 110
Ligger | Nee | 277.8 | +2.868 | +6.351 | C-D/1-2 | A-20(?) | 110
Ligger | Nee | 263.8 | +2.826 | +6.260 | B-C/1-2 | A-20(?) | 140
Ligger | Nee | 329.4 | +2.826 | +6.372 | C-D/1-2 | A-20(?) | 120
Ligger | Nee | 281.1 | +2.828 | +6.351 | C-D/1-2 | A-20(?) | 110
Ligger | Nee | 121.7 | +2.822 | +2.974 | C-D/1-2 | A0(?) | 160
Ligger | Nee | 121.9 | +2.822 | +2.974 | C-D/1-2 | A0(?) | 160
Ligger | Nee | 290.4 | +2.813 | +2.974 | C-D/1-2 | A0(?) | 160
Ligger | Nee | 79.7 | +2.822 | +2.974 | C-D/1-2 | A0(?) | 160
Ligger | Nee | 204.9 | +2.822 | +2.974 | C-D/1-2 | A0(?) | 160
Ligger | Nee | 147.4 | +2.822 | +2.974 | C-D/1-2 | A0(?) | 160
Ligger | Nee | 73.3 | +2.822 | +2.955 | C-D/1-2 | A0(?) | 140
Ligger | Nee | 94.2 | +2.822 | +2.955 | B-D/1-2 | A0(?) | 140
Ligger | Nee | 58.8 | +2.813 | +2.946 | C-D/1-2 | A0(?) | 140
Ligger | Nee | 52.6 | +4.471 | +4.640 | C-E/1-2 | A-20(?) | 140
Ligger | Nee | 30.9 | +2.822 | +2.974 | C-D/2 | A0(?) | 160
Ligger | Nee | 121.3 | +2.822 | +2.974 | C-D/2 | A0(?) | 160
Ligger | Nee | 116.6 | +2.822 | +2.974 | B-D/2 | A0(?) | 160
Ligger | Nee | 143.1 | +2.822 | +2.974 | C-D/2 | A0(?) | 160
Ligger | Nee | 90.9 | +2.822 | +2.974 | C-D/2 | A0(?) | 160
Ligger | Nee | 58.5 | +2.822 | +2.955 | B-C/1-2 | A0(?) | 140
Ligger | Nee | 295.4 | +2.816 | +3.010 | D-E/1 | A-10(?) | 160
Ligger | Nee | 97.7 | +2.837 | +2.970 | B-D/1 | A-10(?) | 140
Ligger | Nee | 73.3 | +2.836 | +2.969 | C-D/1 | A-10(?) | 140
Ligger | Nee | 97.7 | +2.836 | +2.969 | C-D/1 | A-10(?) | 140
Ligger | Nee | 116 | +2.836 | +2.969 | C-D/1 | A-10(?) | 140
Kolom | Nee | 102.4 | -0.050 | +4.102 | E-F/5-6 | A0(?) | 140
Kolom | Nee | 155.3 | -0.050 | +6.250 | E-F/T-5 | A0(?) | 140
Kolom | Nee | 133.2 | -0.050 | +5.352 | E-F/T-5 | A0(?) | 140
Kolom | Nee | 69.8 | -0.050 | +2.783 | E-F/5-6 | A0(?) | 140
Kolom | Nee | 37.9 | -0.250 | +1.289 | E-F/6> | A0(?) | 140
Kolom | Nee | 21.9 | -0.250 | +0.639 | E-F/6> | A0(?) | 140
Kolom | Nee | 31.3 | +3.150 | +4.420 | E-F/1-2 | A0(?) | 140
Kolom | Nee | 33.3 | +3.000 | +4.352 | F/L | A0(?) | 140
Kolom | Nee | 33.3 | +3.000 | +4.352 | F/T | A0(?) | 140
Kolom | Nee | 101.6 | -0.050 | +4.070 | E-F/1-2 | A0(?) | 140
Kolom | Nee | 113.4 | -0.050 | +4.552 | E-F/1-2 | A0(?) | 140
Kolom | Nee | 166 | -0.050 | +5.402 | E-F/1-2 | A0(?) | 160
Kolom | Nee | 111.4 | -0.050 | +4.470 | E-F/1-2 | A0(?) | 140
Kolom | Nee | 109 | -0.070 | +4.352 | E-F/T-5 | A0(?) | 140
Kolom | Nee | 79.4 | -0.070 | +3.152 | E-F/T-5 | A0(?) | 140
4 x Kolom | Nee | 79.4 | -0.070 | +3.152 | E-F/5-6 | A0(?) | 140
Kolom | Nee | 77.6 | +3.152 | +6.301 | G/P | A-20(?) | 140
Kolom | Nee | 76.5 | -0.050 | +3.052 | B/Q | A0(?) | 140
Kolom | Nee | 76.5 | -0.050 | +3.052 | B/S | A0(?) | 140
Kolom | Nee | 105.2 | -0.050 | +4.219 | F/T-5 | A0(?) | 140
Kolom | Nee | 157.7 | -0.050 | +6.346 | E-F/2 | A0(?) | 140
Kolom | Nee | 67.1 | -0.050 | +4.960 | D-E/1-2 | A0(?) | 139.7
2 x Kolom | Nee | 52.6 | -0.050 | +3.883 | D-E/1-2 | A0(?) | 139.7
Kolom | Nee | 71.4 | -0.050 | +2.845 | C-D/1-2 | A0(?) | 140
Kolom | Nee | 70.8 | -0.050 | +2.822 | C-D/1-2 | A0(?) | 140
Kolom | Nee | 67.5 | -0.050 | +4.993 | D-E/1-2 | A0(?) | 139.7
Kolom | Nee | 163.8 | -0.050 | +5.329 | G-H/P | A0(?) | 160
Kolom | Nee | 109 | -0.070 | +4.352 | F/R-S | A0(?) | 140
Kolom | Nee | 109 | -0.070 | +4.352 | F/M-N | A0(?) | 140
Kolom | Nee | 73.5 | -0.070 | +2.912 | V-U/M-N | A0(?) | 140
Kolom | Nee | 39.9 | -0.070 | +2.912 | V-U/T | A0(?) | 139.7
Kolom | Nee | 109 | -0.070 | +4.352 | F/P | A0(?) | 140
Kolom | Nee | 108.4 | -0.050 | +4.352 | F/2 | A0(?) | 140
Kolom | Nee | 79.2 | -0.050 | +3.161 | K-G/1-2 | A0(?) | 140
Kolom | Nee | 165.4 | -0.050 | +5.377 | G/T-5 | A0(?) | 160
Kolom | Nee | 173.8 | -0.050 | +5.656 | V-U/T-5 | A0(?) | 160
Kolom | Nee | 78.7 | +3.152 | +6.344 | W-I/2 | A-20(?) | 140
Kolom | Nee | 78.7 | +3.152 | +6.343 | K/2-L | A-20(?) | 140
Kolom | Nee | 78.7 | +3.152 | +6.345 | K-G/L | A-20(?) | 140
Kolom | Nee | 78.7 | +3.152 | +6.342 | K-G/M | A-20(?) | 140
Kolom | Nee | 78.7 | +3.152 | +6.343 | G/N | A-20(?) | 140
Kolom | Nee | 79.4 | +3.152 | +6.371 | G/O | A0(?) | 140
Kolom | Nee | 79.4 | +3.152 | +6.376 | G/Q | A-20(?) | 140
Kolom | Nee | 78.8 | +3.152 | +6.348 | G/R | A-20(?) | 140
Kolom | Nee | 78.7 | +3.152 | +6.342 | K-G/S | A-20(?) | 140
Kolom | Nee | 78.7 | +3.152 | +6.342 | K-G/T | A-20(?) | 140
Kolom | Nee | 78.7 | +3.152 | +6.342 | K/T-5 | A-20(?) | 140
Kolom | Nee | 78.7 | +3.152 | +6.345 | V/T-5 | A-20(?) | 140
Kolom | Nee | 78.7 | +3.152 | +6.344 | W-I/T-5 | A-20(?) | 140
Kolom | Nee | 72.9 | -0.050 | +2.912 | V-U/P | A0(?) | 140
Kolom | Nee | 133.6 | -0.050 | +5.370 | E-F/1-2 | A0(?) | 140
Kolom | Nee | 165.1 | -0.050 | +5.374 | V-U/1-2 | A0(?) | 160
Kolom | Nee | 165.1 | -0.050 | +5.373 | G/2-L | A0(?) | 160
Kolom | Nee | 66.1 | -0.050 | +3.138 | H/P | A0(?) | 139.7
Kolom | Nee | 72.9 | -0.050 | +2.912 | V-U/R-S | A0(?) | 140
Kolom | Nee | 39.6 | -0.050 | +2.912 | V-U/L | A0(?) | 139.7
Kolom | Nee | 164.5 | -0.050 | +5.352 | G-H/O | A0(?) | 160
Kolom | Nee | 164.9 | -0.050 | +5.364 | G-H/Q | A0(?) | 160
Kolom | Nee | 129.7 | -0.050 | +5.210 | E-F/1-2 | A0(?) | 140
2 x Kolom | Nee | 105.7 | -0.070 | +4.219 | E-F/T-5 | A0(?) | 140
Kolom | Nee | 73.7 | -0.070 | +2.922 | E-F/5-6 | A0(?) | 140
Kolom | Nee | 73.7 | -0.070 | +2.922 | E-F/T-5 | A0(?) | 140
Kolom | Nee | 187 | -0.070 | +6.070 | E/3 | A0(?) | 160
Kolom | Nee | 76.5 | -0.050 | +3.052 | C-D/R | A0(?) | 140
Kolom | Nee | 76.5 | -0.050 | +3.052 | C-D/R-S | A0(?) | 140
2 x Kolom | Nee | 76.5 | -0.050 | +3.052 | C-D/O | A0(?) | 140
Kolom | Nee | 186.4 | -0.050 | +6.070 | D/P | A0(?) | 160
Kolom | Nee | 186.4 | -0.050 | +6.070 | D/3 | A0(?) | 160
3 x Kolom | Nee | 76.5 | -0.050 | +3.052 | C-D/3 | A0(?) | 140
Kolom | Nee | 76.5 | -0.050 | +3.052 | C/3 | A0(?) | 140
Kolom | Nee | 78.8 | -0.050 | +3.152 | A/T-5 | A0(?) | 140
Kolom | Nee | 146.4 | -0.050 | +5.889 | B/5 | A0(?) | 140
Kolom | Nee | 70.2 | -0.050 | +2.803 | A-B/T-5 | A0(?) | 140
Kolom | Nee | 146.4 | -0.050 | +5.889 | B/T-5 | A0(?) | 140
Kolom | Nee | 99.8 | -0.050 | +3.998 | A-B/5-6 | A0(?) | 140
Kolom | Nee | 133 | -0.050 | +5.345 | A-B/5-6 | A0(?) | 140
Kolom | Nee | 75.4 | -0.050 | +3.008 | A/5-6 | A0(?) | 140
Kolom | Nee | 151 | -0.050 | +6.078 | B/5-6 | A0(?) | 140
Kolom | Nee | 99.1 | -0.050 | +3.970 | A-B/T-5 | A0(?) | 140
Kolom | Nee | 133 | -0.050 | +5.344 | A-B/T-5 | A0(?) | 140
Kolom | Nee | 75.4 | -0.050 | +3.008 | A/T-5 | A0(?) | 140
Kolom | Nee | 151 | -0.050 | +6.078 | B/T-5 | A0(?) | 140
Kolom | Nee | 76.5 | -0.050 | +3.052 | B/O-P | A0(?) | 140
Kolom | Nee | 38.8 | -0.050 | +2.847 | D-E/1 | A0(?) | 139.7
Kolom | Nee | 155.5 | -0.050 | +6.260 | B-C/2 | A0(?) | 140
Kolom | Nee | 38.6 | -0.050 | +2.837 | B-C/1 | A0(?) | 139.7
Kolom | Nee | 158.3 | -0.050 | +6.372 | C-D/2 | A0(?) | 140
Kolom | Nee | 157.9 | -0.050 | +6.355 | C-D/2 | A0(?) | 140
2 x Kolom | Nee | 157.7 | -0.050 | +6.351 | C-D/2 | A0(?) | 140
Kolom | Nee | 96.6 | -0.050 | +3.870 | C-D/1-2 | A0(?) | 140
Kolom | Nee | 77.6 | -0.050 | +3.102 | C-D/1 | A0(?) | 140
Kolom | Nee | 96.9 | -0.050 | +3.882 | C-D/1-2 | A0(?) | 140
