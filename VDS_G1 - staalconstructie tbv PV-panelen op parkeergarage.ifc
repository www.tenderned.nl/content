Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:Off], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: VDS_G1 - staalconstructie tbv PV-panelen op par.ifc
Time: 2020-06-29T13:13:24
Author: VD-SLUIS\palland.albert
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2018i Service Pack 5, IFC Export Version: 4.0.0.0 Aug 21 2019

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: HEB220 (2)
In: Undefined
Description: HEB220; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +25.380; Top elevation: +25.600; Phase: 201; Class: 11
Tekla Quantity - Weight: 1165.3 kg; Volume: 0.1 m3; Gross footprint area: 3.5 m2; Area per tons: 17.4 m2; Net surface area: 20.8 m2; Height: 220 mm; Width: 220 mm; Length: 16000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 16000 mm; OuterSurfaceArea: 20.32 m2; NetVolume: 0.141216 m3; NetWeight: 1129.73 kg
Name | Reference
LIGGER | 16
LIGGER | 32

# IfcBeam: HEB300 (2)
In: Undefined
Description: HEB300; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +25.300; Top elevation: +25.600; Phase: 201; Class: 11
Tekla Quantity - Weight: 1908.5 kg; Volume: 0.2 m3; Gross footprint area: 4.8 m2; Area per tons: 14.5 m2; Net surface area: 28.5 m2; Height: 300 mm; Width: 300 mm; Length: 16000 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 16000 mm; OuterSurfaceArea: 27.712 m2; NetVolume: 0.228512 m3; NetWeight: 1828.1 kg
Name | Reference
LIGGER | 15
LIGGER | 31

# IfcBeam: IPE400 (6)
In: Undefined
Description: IPE400; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +25.600; Top elevation: +26.000; Phase: 201; Class: 11
Tekla Quantity - Area per tons: 21.7 m2; Height: 400 mm; Width: 180 mm
Pset_BeamCommon - LoadBearing: no
Name | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LIGGER | 1941.2 | 0.2 | 5.2 | 43.2 | 28729 | 47 | 42.1454 | 0.23178 | 1854.24
3 x LIGGER | 3243.3 | 0.4 | 8.6 | 72.2 | 48000 | 10 | 70.416 | 0.387254 | 3098.04
LIGGER | 3250.7 | 0.4 | 8.7 | 72.3 | 48110 | 29 | 70.5774 | 0.388142 | 3105.13
LIGGER | 1306.7 | 0.2 | 3.5 | 29.1 | 19339 | 27 | 28.3703 | 0.156023 | 1248.19

# IfcBeam: IPE450-675 (3)
In: Undefined
Description: IPE450-675; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +25.325; Top elevation: +26.000; Phase: 201; Class: 11
Tekla Quantity - Area per tons: 20.4 m2; Height: 675 mm; Width: 190 mm
Pset_BeamCommon - LoadBearing: no
Name | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LIGGER | 2227.3 | 0.3 | 5.4 | 59 | 28179 | 39 | 45.3682 | 0.327398 | 2619.19
LIGGER | 1579.1 | 0.2 | 3.8 | 41.8 | 19979 | 22 | 32.1662 | 0.232126 | 1857.01
LIGGER | 3793.9 | 0.5 | 9.1 | 100.4 | 48000 | 3 | 77.28 | 0.557689 | 4461.51

# IfcBeam: K100/6 (4)
In: Undefined
Description: K100/6; Material: STEEL/S235JR
Tekla Common - Phase: 201; Class: 13
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.8 m2; Area per tons: 22 m2; Net surface area: 3.2 m2; Height: 100 mm; Width: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Bottom elevation | Top elevation | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x LIGGER | +25.900 | +26.000 | 138.4 | 8000 | 17 | 3.04 | 0.018048 | 144.384
LIGGER | +25.613 | +25.712 | 136.3 | 7874 | 33 | 2.99212 | 0.0177637 | 142.11

# IfcBeam: K150/5 (16)
In: Undefined
Description: K150/5; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +23.772; Top elevation: +25.378; Phase: 201; Class: 11
Tekla Quantity - Weight: 48.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 25.6 m2; Net surface area: 1.3 m2; Height: 150 mm; Width: 150 mm; Length: 2121.3 mm
Pset_BeamCommon - LoadBearing: no; Reference: 8
BaseQuantities - Length: 2121.32 mm; OuterSurfaceArea: 1.23037 m2; NetVolume: 0.00615183 m3; NetWeight: 49.2146 kg

# IfcBeam: MET-CS232 (4)
In: Undefined
Description: MET-CS232; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +25.762; Top elevation: +26.000; Phase: 201; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.3 m2; Area per tons: 101.9 m2; Net surface area: 2.9 m2; Height: 238 mm; Width: 65 mm
Pset_BeamCommon - LoadBearing: no
Name | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x LIGGER | 28.2 | 3925 | 13 | 2.87099 | 0.00356194 | 28.4955
LIGGER | 28 | 3900 | 30 | 2.85271 | 0.00353925 | 28.314

# IfcBeam: MET-CS342 (2)
In: Undefined
Description: MET-CS342; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +25.651; Top elevation: +26.000; Phase: 201; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.7 m2; Area per tons: 77.7 m2; Height: 349 mm; Width: 90 mm
Pset_BeamCommon - LoadBearing: no
Name | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LIGGER | 106.3 | 8.3 | 7850 | 4 | 8.2584 | 0.0131277 | 105.022
LIGGER | 105.9 | 8.2 | 7820 | 23 | 8.22686 | 0.0130775 | 104.62

# IfcBeam: PL50*1000 (2)
In: Undefined
Description: PL50*1000; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +26.050; Top elevation: +26.324; Phase: 201; Class: 0
Tekla Quantity - Weight: 660 kg; Volume: 0.1 m3; Gross footprint area: 0 m2; Area per tons: 5.4 m2; Net surface area: 3.6 m2; Height: 1000 mm; Width: 50 mm; Length: 1650 mm
Pset_BeamCommon - LoadBearing: no; Reference: 6
BaseQuantities - Length: 1650 mm; OuterSurfaceArea: 3.565 m2; NetVolume: 0.0825 m3; NetWeight: 660 kg

# IfcBeam: SAB-30KD/1050-0.75 (2)
In: Undefined
Description: SAB-30KD/1050-0.75; Material: STEEL/S235JR
Tekla Common - Phase: 201; Class: 0
Tekla Quantity - Volume: 0 m3; Area per tons: 140.1 m2; Height: 30.8 mm; Width: 1122.6 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LIGGER | +25.731 | +25.762 | 119.9 | 0.6 | 40.1 | 16000 | 14 | 16.8 | 0.0150059 | 120.047
LIGGER | +25.620 | +25.651 | 112.5 | 0.5 | 37.6 | 15000 | 5 | 15.75 | 0.0140681 | 112.544

# IfcBeam: U50/3 (4)
In: Undefined
Description: U50/3; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +26.000; Top elevation: +26.050; Phase: 201; Class: 0
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 85.2 m2; Net surface area: 0.4 m2; Height: 50 mm; Width: 50 mm; Length: 1500 mm
Pset_BeamCommon - LoadBearing: no; Reference: 7
BaseQuantities - Length: 1500 mm; OuterSurfaceArea: 0.441864 m2; NetVolume: 0.000648 m3; NetWeight: 5.184 kg

# IfcColumn: K200/8 (20)
In: Undefined
Description: K200/8; Material: STEEL/S235JR
Tekla Common - Phase: 201; Class: 4
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 16.2 m2; Height: 200 mm; Width: 200 mm
Pset_ColumnCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | Reference | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
3 x KOLOM | +20.000 | +25.340 | 253.1 | 4.3 | 5340 | 9 | 4.1118 | 0.032809 | 262.472
3 x KOLOM | +20.000 | +25.200 | 246.4 | 4.2 | 5200 | 12 | 4.004 | 0.0319488 | 255.59
KOLOM | +23.000 | +25.200 | 104.3 | 1.8 | 2200 | 11 | 1.694 | 0.0135168 | 108.134
KOLOM | +20.000 | +25.284 | 250.4 | 4.2 | 5284 | 26 | 4.06868 | 0.0324649 | 259.719
KOLOM | +23.000 | +25.364 | 112 | 1.9 | 2364 | 25 | 1.82028 | 0.0145244 | 116.195
6 x KOLOM | +20.000 | +26.000 | 284.4 | 4.8 | 6000 | 2 | 4.62 | 0.036864 | 294.912
KOLOM | +23.000 | +26.000 | 142.2 | 2.4 | 3000 | 1 | 2.31 | 0.018432 | 147.456
KOLOM | +20.000 | +25.309 | 251.6 | 4.3 | 5309 | 21 | 4.08793 | 0.0326185 | 260.948
KOLOM | +23.000 | +25.309 | 109.4 | 1.9 | 2309 | 20 | 1.77793 | 0.0141865 | 113.492
KOLOM | +20.000 | +25.325 | 252.4 | 4.3 | 5325 | 19 | 4.10025 | 0.0327168 | 261.734
KOLOM | +23.000 | +25.325 | 110.2 | 1.9 | 2325 | 18 | 1.79025 | 0.0142848 | 114.278

# IfcDiscreteAccessory: LIGGER (4)
In: Undefined
Description: K150/5; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +23.819; Phase: 201; Class: 11
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 25.6 m2; Height: 150 mm; Width: 150 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.002835 m2
Name | Top elevation | Weight (kg) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) = GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x LIGGER | +25.584 | 56.6 | 1.4 | 2496.2 | 28 | 1.44778 | 0.00680392 | 0.00707667
2 x LIGGER | +25.309 | 47.8 | 1.2 | 2107.3 | 24 | 1.22222 | 0.00567609 | 0.00597411

# IfcDiscreteAccessory: MERK (2)
In: Undefined
Material: STEEL/S235JR
Tekla Common - Phase: 201; Class: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Width: 10 mm
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Height (mm) | Length (mm) | LoadBearing | Reference | NetArea (m2) = GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
MERK | STRIP10*180 | +25.791 | +25.971 | 2.9 | 27.6 | 180 | 200 | yes | 46 | 0.0796 | 0.0018 | 0.00036
MERK | STRIP10*250 | +25.701 | +25.951 | 4.2 | 27.2 | 210 | 210 | no | 36 | 0.1142 | 0.0025 | 0.000525

# IfcDiscreteAccessory: PLAAT (15)
In: Undefined
Material: STEEL/S235JR
Tekla Common - Phase: 201; Class: 99
Tekla Quantity - Volume: 0 m3
Pset_PlateCommon - LoadBearing: yes
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | CrossSectionArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLAAT | PL20*190 | +25.610 | +25.990 | 11.6 | 0 | 14.5 | 0.2 | 190 | 20 | 380 | 48 | 0.1672 | 0.1672 | 0.0038 | 0.001444
PLAAT | STRIP15*400 | +25.364 | +25.379 | 10.1 | 0.1 | 18.5 | 0.2 | 210 | 15 | 210 | 43 | 0.1863 | 0.1863 | 0.006 | 0.00126
PLAAT | PL10*171.9 | +25.126 | +25.300 | 2.3 | 0 | 28.5 | 0.1 | 171.9 | 10 | 305.7 | 44 | 0.0656106 | 0.0525465 | 0.0001 | 0.000288158
2 x PLAAT | STRIP15*400 | +25.584 | +25.599 | 10.1 | 0.1 | 18.5 | 0.2 | 210 | 15 | 210 | 43 | 0.1863 | 0.1863 | 0.006 | 0.00126
PLAAT | STRIP15*230 | +25.284 | +25.299 | 11 | 0.1 | 18.4 | 0.2 | 230 | 15 | 400 | 34 | 0.2029 | 0.2029 | 0.006 | 0.00138
2 x PLAAT | STRIP20*220 | +25.332 | +25.992 | 23.2 | 0 | 14 | 0.3 | 220 | 20 | 660 | 40 | 0.3256 | 0.3256 | 0.0044 | 0.002904
PLAAT | PL10*174.5 | +25.438 | +25.613 | 3 | 0 | 27.5 | 0.1 | 174.5 | 10 | 227.7 | 38 | 0.0833129 | 0.0397247 | 0.0001 | 0.000378123
PLAAT | STRIP15*250 | +25.538 | +25.788 | 9 | 0 | 18.5 | 0.2 | 250 | 15 | 300 | 37 | 0.1665 | 0.1665 | 0.0045 | 0.001125
4 x PLAAT | STRIP15*230 | +25.309 | +25.324 | 11 | 0.1 | 18.4 | 0.2 | 230 | 15 | 400 | 34 | 0.2029 | 0.2029 | 0.006 | 0.00138

# IfcDiscreteAccessory: SCHOTJE (36)
In: Undefined
Material: STEEL/S235JR
Tekla Common - Phase: 201; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Width: 10 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0001 m2
Name | Description | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
12 x SCHOTJE | STRIP10*80 | +25.614 | +25.985 | 2.3 | 28.8 | 0.1 | 80 | 371 | 42 | 0.0668371 | 0.02968 | 0.00029055
12 x SCHOTJE | STRIP10*90 | +25.341 | +25.984 | 4.6 | 28.1 | 0.1 | 90 | 643.8 | 35 | 0.129017 | 0.057942 | 0.00057317
6 x SCHOTJE | STRIP10*140 | +25.320 | +25.580 | 2.8 | 27.7 | 0.1 | 140 | 260 | 41 | 0.0786485 | 0.0364 | 0.000355
6 x SCHOTJE | STRIP10*100 | +25.397 | +25.583 | 1.5 | 28.8 | 0 | 100 | 186 | 45 | 0.0418857 | 0.0186 | 0.000182

# IfcDiscreteAccessory: WINDVERBAND (2)
In: Undefined
Description: STRIP8*90; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +22.957; Top elevation: +25.543; Phase: 201; Class: 13
Tekla Quantity - Weight: 48.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 34.1 m2; Net surface area: 1.6 m2; Height: 90 mm; Width: 8 mm; Length: 8381.5 mm
Pset_PlateCommon - LoadBearing: yes; Reference: g6
BaseQuantities - NetArea: 1.64422 m2; GrossArea: 1.64422 m2; CrossSectionArea: 0.00072 m2; NetVolume: 0.0060347 m3; GrossVolume: 0.0060347 m3

# IfcElementAssembly (83)
In: Undefined
PredefinedType: RIGID_FRAME
Name | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm)
Steel Assembly | 1339.7 | +25.600 | +26.000 | P06/PB-PE | L15 | 299.3
Steel Assembly | 1652.4 | +25.325 | +26.000 | P03/PB-PE | L13 | 324.7
Steel Assembly | 1952.7 | +25.600 | +26.000 | P06/PD-PH | L22 | 190
Steel Assembly | 3260 | +25.600 | +26.000 | P05-P06/PB-PH | L16 | 180
Steel Assembly | 1927.8 | +25.126 | +25.600 | P05-P07/PD | L18 | 300
Steel Assembly | 1174 | +25.380 | +25.600 | P05-P07/PB | L19 | 220
Steel Assembly | 28 | +25.762 | +26.000 | P05-P06/PB-PC | L17 | 65
Steel Assembly | 122.1 | +23.000 | +25.379 | P06/PB | K10 | 400
Steel Assembly | 53.2 | +19.963 | +25.280 | P05-P06/PD | W10 | 8
Steel Assembly | 394.8 | +20.000 | +25.599 | P06/PD | K11 | 400
Steel Assembly | 2250.5 | +25.325 | +26.000 | P03/PD-PH | L21 | 220
Steel Assembly | 55.2 | +19.963 | +25.592 | P02-P03/PD | W8 | 8
Steel Assembly | 148.3 | +25.438 | +25.788 | P02-P03/PD | L20 | 300
Steel Assembly | 3803.1 | +25.325 | +26.000 | P02/PB-PH | L1 | 190
Steel Assembly | 105.9 | +25.651 | +26.000 | P02-P03/PB-PC | L14 | 90
Steel Assembly | 120.5 | +23.000 | +25.324 | P03/PB | K8 | 400
Steel Assembly | 380.3 | +20.000 | +25.324 | P03/PD | K9 | 3368
Steel Assembly | 138.4 | +25.900 | +26.000 | P02-P03/PB | L12 | 100
Steel Assembly | 138.4 | +25.900 | +26.000 | P02-P03/PH | L12 | 100
Steel Assembly | 138.4 | +25.900 | +26.000 | P02-P03/PF | L12 | 100
2 x Steel Assembly | 48.3 | +22.957 | +25.543 | P05-P06/PB | W6 | 8
Steel Assembly | 56.2 | +19.963 | +25.637 | P05-P06/PH | W5 | 8
Steel Assembly | 56.3 | +19.963 | +25.622 | P05-P06/PH | W4 | 8
Steel Assembly | 57.6 | +19.964 | +26.036 | P05-P06/PF | W3 | 8
Steel Assembly | 57.7 | +19.964 | +26.021 | P05-P06/PF | W2 | 8
Steel Assembly | 55.8 | +19.963 | +25.473 | P05-P06/PD | W9 | 8
Steel Assembly | 57.6 | +19.964 | +26.036 | P02-P03/PH | W3 | 8
Steel Assembly | 57.7 | +19.964 | +26.021 | P02-P03/PH | W2 | 8
Steel Assembly | 57.6 | +19.964 | +26.036 | P02-P03/PF | W3 | 8
Steel Assembly | 57.7 | +19.964 | +26.021 | P02-P03/PF | W2 | 8
Steel Assembly | 56.6 | +19.963 | +25.699 | P02-P03/PD | W7 | 8
2 x Steel Assembly | 49.2 | +22.958 | +26.042 | P02-P03/PB | W1 | 8
Steel Assembly | 253.1 | +20.000 | +25.340 | P07/PH | K3 | 200
Steel Assembly | 48.1 | +23.772 | +25.378 | P07/PE-PF | L6 | 150
Steel Assembly | 48.1 | +23.772 | +25.378 | P07/PF-PG | L6 | 150
Steel Assembly | 246.4 | +20.000 | +25.200 | P07/PF | K5 | 200
Steel Assembly | 48.1 | +23.772 | +25.378 | P06/PE-PF | L6 | 150
Steel Assembly | 48.1 | +23.772 | +25.378 | P06/PF-PG | L6 | 150
Steel Assembly | 246.4 | +20.000 | +25.200 | P06/PF | K5 | 200
Steel Assembly | 1165.3 | +25.380 | +25.600 | P05-P07/PH | L11 | 220
Steel Assembly | 1908.5 | +25.300 | +25.600 | P05-P07/PF | L10 | 300
Steel Assembly | 104.3 | +23.000 | +25.200 | P07/PB | K4 | 200
Steel Assembly | 3243.3 | +25.600 | +26.000 | P06-P07/PB-PH | L7 | 180
Steel Assembly | 3243.3 | +25.600 | +26.000 | P07/PB-PH | L7 | 180
Steel Assembly | 48.1 | +23.772 | +25.378 | P07/PC-PD | L6 | 150
Steel Assembly | 48.1 | +23.772 | +25.378 | P07/PD-PE | L6 | 150
Steel Assembly | 246.4 | +20.000 | +25.200 | P07/PD | K5 | 200
3 x Steel Assembly | 28.2 | +25.762 | +26.000 | P05-P06/PB-PC | L8 | 65
Steel Assembly | 48.1 | +23.772 | +25.378 | P05/PE-PF | L6 | 150
Steel Assembly | 48.1 | +23.772 | +25.378 | P05/PF-PG | L6 | 150
Steel Assembly | 48.1 | +23.772 | +25.378 | P05/PC-PD | L6 | 150
Steel Assembly | 48.1 | +23.772 | +25.378 | P05/PD-PE | L6 | 150
Steel Assembly | 5.2 | +26.000 | +26.050 | P05-P06/PB-PC | L5 | 50
Steel Assembly | 5.2 | +26.000 | +26.050 | P05/PB-PC | L5 | 50
Steel Assembly | 660 | +26.050 | +26.324 | P05-P06/PB-PC | L4 | 50
Steel Assembly | 119.9 | +25.731 | +25.762 | P05-P06/PB-PD | L9 | 1122.6
Steel Assembly | 253.1 | +20.000 | +25.340 | P06/PH | K3 | 200
Steel Assembly | 3243.3 | +25.600 | +26.000 | P05/PB-PH | L7 | 180
Steel Assembly | 253.1 | +20.000 | +25.340 | P05/PH | K3 | 200
Steel Assembly | 284.4 | +20.000 | +26.000 | P05/PF | K2 | 200
Steel Assembly | 284.4 | +20.000 | +26.000 | P05/PD | K2 | 200
Steel Assembly | 142.2 | +23.000 | +26.000 | P05/PB | K1 | 200
Steel Assembly | 48.1 | +23.772 | +25.378 | P03/PE-PF | L6 | 150
Steel Assembly | 48.1 | +23.772 | +25.378 | P03/PF-PG | L6 | 150
Steel Assembly | 48.1 | +23.772 | +25.378 | P02/PE-PF | L6 | 150
Steel Assembly | 48.1 | +23.772 | +25.378 | P02/PF-PG | L6 | 150
Steel Assembly | 48.1 | +23.772 | +25.378 | P02/PC-PD | L6 | 150
Steel Assembly | 48.1 | +23.772 | +25.378 | P02/PD-PE | L6 | 150
Steel Assembly | 5.2 | +26.000 | +26.050 | P02-P03/PB-PC | L5 | 50
Steel Assembly | 5.2 | +26.000 | +26.050 | P02/PB-PC | L5 | 50
Steel Assembly | 660 | +26.050 | +26.324 | P02-P03/PB-PC | L4 | 50
Steel Assembly | 106.3 | +25.651 | +26.000 | P02-P03/PB-PC | L2 | 90
Steel Assembly | 112.5 | +25.620 | +25.651 | P02-P03/PB-PD | L3 | 1122.6
Steel Assembly | 284.4 | +20.000 | +26.000 | P03/PH | K2 | 200
Steel Assembly | 284.4 | +20.000 | +26.000 | P03/PF | K2 | 200
Steel Assembly | 284.4 | +20.000 | +26.000 | P02/PH | K2 | 200
Steel Assembly | 284.4 | +20.000 | +26.000 | P02/PF | K2 | 200
Steel Assembly | 252.4 | +20.000 | +25.325 | P02/PD | K7 | 200
Steel Assembly | 110.2 | +23.000 | +25.325 | P02/PB | K6 | 200

# IfcMechanicalFastener: Bolt assembly (19)
In: Undefined
Material: Undefined
Tekla Bolt - Slotted hole y: 0 mm; Location: Montage; Bolt Name: BOUT
Name | NominalDiameter (mm) = Washer diameter (mm) = Bolt size (mm) | NominalLength (mm) = Bolt length (mm) | Washer count | Washer type | Washer name | Nut count = Bolt count | Nut type | Nut name | Slotted hole x (mm) | Bolt hole diameter (mm) | Bolt standard
Bolt assembly | 20 | 70 | 8 | 125A | RING-M20 | 8 | 934 | MOER-M20 | 0 | 25 | 931-8.8
2 x Bolt assembly | 20 | 65 | 8 | 7089 | RING-M20-7089 | 4 | 4032 | MOER-M20-4032 | 0 | 24 | 4014-8.8
2 x Bolt assembly | 16 | 40 | 4 | 7089 | RING-M16-7089 | 2 | 4032 | MOER-M16-4032 | 20 | 20 | 4014-8.8
2 x Bolt assembly | 20 | 60 | 8 | 7089 | RING-M20-7089 | 4 | 4032 | MOER-M20-4032 | 0 | 24 | 4014-8.8
2 x Bolt assembly | 20 | 60 | 4 | 125A | RING-M20 | 4 | 934 | MOER-M20 | 0 | 25 | 931-8.8
2 x Bolt assembly | 16 | 40 | 2 | 125A | RING-M16 | 2 | 934 | MOER-M16 | 0 | 20 | 931-8.8
7 x Bolt assembly | 20 | 55 | 4 | 125A | RING-M20 | 4 | 934 | MOER-M20 | 0 | 25 | 931-8.8
Bolt assembly | 20 | 70 | 10 | 125A | RING-M20 | 10 | 934 | MOER-M20 | 0 | 25 | 931-8.8

# IfcMember: STRIP8*90 (14)
In: Undefined
Description: STRIP8*90; Material: STEEL/S235JR
Tekla Common - Phase: 201; Class: 13
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 34.1 m2; Height: 90 mm; Width: 8 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00072 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) = GrossVolume (m3) | NetWeight (kg) = GrossWeight (kg)
WINDVERBAND | +19.963 | +25.637 | 56.2 | 1.9 | 9765.2 | g5 | 9765.24 | 1.91543 | 0.00703098 | 56.2478
WINDVERBAND | +19.963 | +25.622 | 56.3 | 1.9 | 9775.8 | g4 | 9775.78 | 1.91749 | 0.00703856 | 56.3085
3 x WINDVERBAND | +19.964 | +26.036 | 57.6 | 2 | 10000 | g3 | 10000 | 1.96144 | 0.0072 | 57.6
3 x WINDVERBAND | +19.964 | +26.021 | 57.7 | 2 | 10009.7 | g2 | 10009.7 | 1.96334 | 0.00720699 | 57.6559
WINDVERBAND | +19.963 | +25.280 | 53.2 | 1.8 | 9232.9 | g10 | 9232.92 | 1.81109 | 0.00664771 | 53.1816
WINDVERBAND | +19.963 | +25.473 | 55.8 | 1.9 | 9690.7 | g9 | 9690.69 | 1.90082 | 0.0069773 | 55.8184
WINDVERBAND | +19.963 | +25.592 | 55.2 | 1.9 | 9590.9 | g8 | 9590.88 | 1.88125 | 0.00690543 | 55.2434
WINDVERBAND | +19.963 | +25.699 | 56.6 | 1.9 | 9819.9 | g7 | 9819.87 | 1.92614 | 0.00707031 | 56.5625
2 x WINDVERBAND | +22.958 | +26.042 | 49.2 | 1.7 | 8544 | g1 | 8544 | 1.67606 | 0.00615168 | 49.2135
