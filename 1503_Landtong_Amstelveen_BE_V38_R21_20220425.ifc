Properties of the parts of a building model (IFC2X3), part 13 of 13

# IfcFlowSegment: Round Duct:Luka rond - verzinkt staal (T-stuk) (614)
Name (Round Duct:Luka rond - verzinkt staal (T-stuk):...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
2313611 | 00 | 1024.2 | mvr 5
2314113 | 01 | 571.772 | mvt lbk1
2314502 | 01 | 137.92 | mvt lbk1
2314750 | 01 | 169.045 | mvt lbk1
2314947 | 01 | 552.264 | mvt lbk1
2315334 | 00 | 275.65 | mvr 5
2315381 | 00 | 2159.97 | mvr 5
2315450 | 00 | 81.5714 | mvr 5
2315578 | 00 | 108.368 | mvr 5
2316139 | 00 | 82.5 | mvr 5
2316326 | 00 | 186.713 | mvr 5
2316772 | 00 | 2692.72 | mvr 5
2317153 | 00 | 1020 | mvt lbk1
2317177 | 00 | 639.525 | mvt lbk1
2317692 | 00 | 93.95 | mvr 5
2318634 | 00 | 82.4599 | mvr 5
2318671 | 00 | 270.316 | mvr 5
2318963 | 00 | 32.75 | mvr 5
2319031 | 00 | 32.75 | mvr 5
2319612 | 00 | 267.775 | mvr 5
2319888 | 00 | 207.25 | mvr 5
2320120 | 00 | 66.0526 | mvr 5
2320122 | 00 | 1780.47 | mvr 5
2320126 | 00 | 82.4599 | mvr 5
2320132 | 00 | 270.316 | mvr 5
2320135 | 00 | 32.75 | mvr 5
2320138 | 00 | 32.75 | mvr 5
2320148 | 00 | 267.775 | mvr 5
2320151 | 00 | 207.25 | mvr 5
2320666 | 00 | 1979.05 | mvr 5
2320743 | 00 | 436.07 | mvr 5
2320749 | 00 | 174.827 | mvr 5
2321678 | 00 | 174.408 | mvt lbk1
2321684 | 00 | 186.442 | mvt lbk1
2321749 | 00 | 82.5 | mvt lbk1
2322117 | 00 | 556.653 | mvt lbk1
2322269 | 00 | 124.163 | mvt lbk1
2322361 | 00 | 95.4246 | mvt lbk1
2322367 | 00 | 447.022 | mvt lbk1
2322582 | 00 | 2106.5 | mvt lbk1
2322642 | 00 | 653.6 | mvt lbk1
2323083 | 00 | 28.75 | mvt lbk1
2323177 | 00 | 68.675 | mvt lbk1
2323452 | 00 | 762.85 | mvt lbk1
2323455 | 00 | 762.85 | mvt lbk1
2323464 | 00 | 155.55 | mvt lbk1
2323474 | 00 | 173.675 | mvt lbk1
2323478 | 00 | 152.666 | mvt lbk1
2323484 | 00 | 34.4083 | mvt lbk1
2323486 | 00 | 186.442 | mvt lbk1
2323489 | 00 | 222.5 | mvt lbk1
2323492 | 00 | 57.2033 | mvt lbk1
2323494 | 00 | 575.425 | mvt lbk1
2323496 | 00 | 447.022 | mvt lbk1
2323508 | 00 | 1996.5 | mvt lbk1
2323511 | 00 | 193.6 | mvt lbk1
2323518 | 00 | 28.75 | mvt lbk1
2323521 | 00 | 68.675 | mvt lbk1
2323842 | 00 | 3134.13 | mvt lbk1
2323953 | 00 | 10366.7 | mvt lbk1
2323988 | 00 | 310.564 | mvt lbk1
2324092 | 00 | 422.583 | mvt lbk1
2325450 | 00 | 33.4908 | mvr 5
2325913 | 00 | 947.344 | mvr 5
2326139 | 00 | 105 | mvr 5
2326266 | 00 | 356.627 | mvr 5
2327042 | 00 | 165 | mvr 5
2327050 | 00 | 192.655 | mvr 5
2327116 | 00 | 220 | mvr 5
2327648 | 00 | 267.345 | mvr 5
2328448 | 00 | 494.338 | mvr 5
2328498 | 00 | 175.886 | mvr 5
2328576 | 00 | 2693.15 | mvr 5
2328584 | 00 | 272.337 | mvr 5
2328926 | 00 | 87.5 | mvt lbk1
2329033 | 00 | 1964.17 | mvt lbk1
2329425 | 00 | 300.674 | mvt lbk1
2332017 | 00 | 10180 | mvt lbk1
2333051 | 00 | 675.65 | mvt lbk1
2334193 | 00 | 185.625 | mvt lbk1
2335778 | 00 | 1182.24 | mvr 5
2336153 | 00 | 12738.4 | mvr 5
2336161 | 00 | 2829.99 | mvr 5
2337312 | 00 | 68.7924 | mvr 5
2337619 | 00 | 71.8823 | mvr 5
2337843 | 00 | 43.7924 | mvr 5
2337900 | 00 | 66.8823 | mvr 5
2338323 | 00 | 134.562 | mvr 5
2338381 | 00 | 134.562 | mvr 5
2436208 | 01 | 10.6833 | mvt 2
2436211 | 01 | 10.6833 | mvt 2
2436220 | 01 | 10.6833 | mvt 2
2436226 | 01 | 155.55 | mvt 2
2436228 | 01 | 1186.7 | mvt 2
2436232 | 01 | 1171.71 | mvt 2
2436236 | 01 | 480.584 | mvt 2
2436247 | 01 | 37.2404 | mvt 2
2436258 | 01 | 751.16 | mvt 2
2436267 | 01 | 10.6833 | mvt 2
2436278 | 01 | 158.05 | mvt 2
2436284 | 01 | 3150.74 | mvt 2
2436286 | 01 | 369.198 | mvt 2
2436316 | 01 | 47.1927 | mvt 2
2436333 | 01 | 150.67 | mvt 2
2436334 | 01 | 21.6977 | mvt 2
2436342 | 01 | 62.7677 | mvt 2
2436344 | 01 | 1589.5 | mvt 2
2436346 | 01 | 5201.76 | mvt 2
2436356 | 01 | 51 | mvt 2
2436363 | 01 | 65.72 | mvt 2
2436364 | 01 | 21.6977 | mvt 2
2436374 | 01 | 1879.25 | mvt 2
2436377 | 01 | 77.5 | mvt 2
2436380 | 01 | 511.586 | mvt 2
2445216 | 01 | 22.5713 | mvr 5
2445252 | 01 | 1808.07 | mvr 5
2445253 | 01 | 230.485 | mvr 5
2477108 | 01 | 5.4924 | mvr 5
2477202 | 01 | 5.4924 | mvr 5
2481317 | 01 | 176.761 | mvr 5
2481341 | 01 | 31.2706 | mvr 5
2481414 | 01 | 130.825 | mvr 5
2490625 | 01 | 65.8435 | mvt 2
2497037 | 01 | 299.924 | mvt 2
2497459 | 01 | 182.052 | mvt 2
2497570 | 01 | 284.564 | mvt 2
2497861 | 01 | 165.005 | mvt 2
2497867 | 01 | 30.596 | mvt 2
2525608 | 00 | 115.311 | mvr 5
2525857 | 00 | 43.3399 | mvr 5
2526072 | 00 | 2897.5 | mvr 5
2526697 | 00 | 4100.41 | mvr 5
2528710 | 01 | 74.9 | mvt lbk1
2529118 | 01 | 1397.18 | mvt lbk1
2529221 | 01 | 99.15 | mvt lbk1
2530585 | 01 | 135.808 | mvt lbk1
2560018 | 02 | 2436.82 | mvt lbk1
2560475 | 01 | 99.15 | mvt lbk1
2560535 | 02 | 337.048 | mvt lbk1
2560542 | 01 | 20 | mvt lbk1
2563175 | 02 | 685 | mvt lbk1
2563523 | 01 | 95.5381 | mvt lbk1
2563534 | 01 | 595.452 | mvt lbk1
2563835 | 02 | 109.835 | mvt lbk1
2564125 | 02 | 127.665 | mvt lbk1
2575272 | F | 1600 | mvaf 4
2576741 | 00 | 33.1447 | mvr 5
2576747 | 00 | 33.2237 | mvr 5
2576827 | 00 | 120.137 | mvr 5
2576835 | 00 | 78.8871 | mvr 5
2577184 | 00 | 11.3871 | mvr 5
2577216 | 00 | 45.1371 | mvr 5
2581646 | 00 | 635.198 | mvr 5
2582543 | 00 | 108.05 | mvt lbk1
2583376 | 00 | 331.499 | mvr 5
2583518 | 00 | 174.013 | mvr 5
2583560 | 00 | 1260.76 | mvr 5
2583861 | 00 | 505.854 | mvr 5
2583878 | 00 | 3201.9 | mvr 5
2583887 | 00 | 593.492 | mvr 5
2584105 | 00 | 392.5 | mvr 5
2584331 | 00 | 1339.01 | mvr 5
2584550 | 00 | 311.521 | mvr 5
2584552 | 00 | 174.013 | mvr 5
2584602 | 00 | 3997.8 | mvr 5
2584654 | 00 | 128.897 | mvr 5
2584762 | 00 | 499.668 | mvr 5
2585206 | 00 | 253.57 | mvr 5
2589599 | 00 | 175.575 | mvt lbk1
2590784 | 00 | 384.83 | mvr 5
2590988 | 00 | 133.953 | mvr 5
2591090 | 00 | 107.5 | mvt lbk1
2591703 | 00 | 2700 | mvt lbk1
2592220 | 00 | 1218.07 | mvr 5
2592406 | 00 | 132.5 | mvr 5
2592677 | 00 | 192.075 | mvt lbk1
2593534 | 00 | 101.548 | mvt lbk1
2595682 | 00 | 83.0127 | mvr 5
2595759 | 00 | 413.762 | mvr 5
2595882 | 00 | 98.6212 | mvr 5
2595924 | 00 | 98.6212 | mvr 5
2599508 | 01 | 490.993 | mvr 5
2600745 | 01 | 144.819 | mvr 5
2600794 | 01 | 275 | mvr 5
2601365 | 01 | 1289.39 | mvr 5
2601422 | 01 | 38.8269 | mvr 5
2602023 | 01 | 258.094 | mvr 5
2602602 | 01 | 131.961 | mvr 5
2603499 | 02 | 537.5 | mvr 5
2603656 | 02 | 85 | mvr 5
2604331 | 02 | 20 | mvr 5
2605678 | 01 | 120.208 | mvr 5
2605687 | 01 | 1074.07 | mvr 5
2605839 | 02 | 542.5 | mvt lbk1
2606025 | 02 | 452.5 | mvr 5
2606033 | 02 | 1053.97 | mvr 5
2607031 | 02 | 66.25 | mvr 5
2607122 | 02 | 1001.25 | mvr 5
2610098 | 00 | 50.3434 | mvt lbk1
2610145 | 00 | 4035.32 | mvt lbk1
2610968 | 00 | 4112.15 | mvt lbk1
2611025 | 00 | 1884.81 | mvt lbk1
2611031 | 00 | 949.251 | mvt lbk1
2611172 | 00 | 51.3528 | mvt lbk1
2611219 | 00 | 1885.82 | mvt lbk1
2611536 | 00 | 952.975 | mvt lbk1
2611545 | 00 | 117.3 | mvt lbk1
2611550 | 00 | 1656.72 | mvt lbk1
2611742 | 00 | 1923.22 | mvt lbk1
2612008 | 00 | 273.335 | mvt lbk1
2612070 | 00 | 29.787 | mvt lbk1
2612084 | 00 | 49.917 | mvt lbk1
2612845 | 00 | 835 | mvr 5
2612921 | 00 | 728.787 | mvr 5
2613063 | 00 | 112.078 | mvr 5
2613162 | 00 | 44.5775 | mvr 5
2616910 | 01 | 125 | mvt 2
2617436 | 01 | 76.402 | mvt 2
2617475 | 01 | 712.654 | mvt 2
2617485 | 01 | 356.755 | mvt 2
2617509 | 01 | 1632.59 | mvt 2
2617767 | 01 | 112.027 | mvt 2
2619055 | 01 | 1632.95 | mvt 2
2624246 | 01 | 40.2375 | mvr 5
2624350 | 01 | 58.6642 | mvr 5
2639196 | 01 | 99.7704 | mvr 5
2639493 | 01 | 31 | mvr 5
2640954 | 00 | 82.5 | mvr 5
2641257 | 00 | 270.582 | mvt lbk1
2709633 | 00 | 304.163 | mvt lbk1
2711570 | 00 | 112.5 | mvt lbk1
2711623 | 00 | 108.797 | mvt lbk1
2713929 | 00 | 72.2033 | mvt lbk1
2714696 | 00 | 103.797 | mvt lbk1
2714732 | 00 | 142.5 | mvt lbk1
2723700 | 00 | 569.751 | mvt lbk1
2724255 | 00 | 276.864 | mvt lbk1
2725237 | 00 | 149.031 | mvt lbk1
2725249 | 00 | 639.525 | mvt lbk1
2725317 | 00 | 332.551 | mvt lbk1
2725487 | 00 | 273.87 | mvt lbk1
2725697 | 00 | 274.79 | mvt lbk1
2745098 | 00 | 738.579 | mvr 5
2745158 | 00 | 482.843 | mvr 5
2758337 | 00 | 312.126 | mvr 5
2766335 | 01 | 23.1311 | mvr 5
2774082 | 00 | 332.551 | mvr 5
2775391 | 00 | 134.195 | mvr 5
2920475 | 01 | 221.85 | mvt lbk1
2920770 | 01 | 221.85 | mvt lbk1
2921015 | 01 | 74.9 | mvt lbk1
2921039 | 01 | 4225.01 | mvt lbk1
2921055 | 01 | 823.891 | mvt lbk1
2921378 | 01 | 327.534 | mvt lbk1
2921476 | 01 | 1193.05 | mvt lbk1
2922161 | 01 | 1969.24 | mvr 1
2922252 | 01 | 1969.24 | mvr 5

# IfcFlowStorageDevice: NLRS_50_ME_UN_Expansievat_Flamco_Flexcon:Flexcon 50L, NLRS_50_ME_UN_Expansievat_Flamco_Flexcon:Flexcon 50L:1246547
In: 00
Type - PredefinedType: EXPANSION; Classification: 56.10 (Uniformat); Material: staal_rood
Type - Pset_ManufacturerTypeInformation - Manufacturer: Flamco
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_DistributionFlowElementCommon - Reference: Flexcon 50L; sets with these values: 2
Group: brr 1

# IfcFlowTerminal: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior S4A:S4A, M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior S4A:S4A:1348813
In: 00
Type - PredefinedType: WASTETRAP; Material: Color RAL 1003, Color RGB 255-000-000, Color RGB 000-255-000, Color RGB 168-168-168, Color RGB 250-250-250
Type - Pset_ElectricalDeviceCommon - NominalCurrent: 0.5 A
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Material: Color RGB 250-250-250, Color RGB 168-168-168, Color RGB 255-000-000, Color RGB 000-255-000, Color RAL 1003
Pset_DistributionFlowElementCommon - Reference: S4A; sets with these values: 2

# IfcFlowTerminal: NLRS_57_AIR_UN_deurspleet _toevoer_gen_ISR:standaard (46)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: standaard; sets with these values: 2
Name (NLRS_57_AIR_UN_deurspleet _toevoer_gen_ISR:standaard:...) | In
2622048 | 01
2622055 | 01
2622062 | 01
2622076 | 01
2622083 | 01
2622090 | 01
2622097 | 01
2622104 | 01
2622111 | 01
2622118 | 01
2622125 | 01
2622132 | 01
2622139 | 01
2622146 | 01
2622153 | 01
2622160 | 01
2622183 | 00
2622311 | 00
2622328 | 00
2622358 | 00
2622373 | 00
2622392 | 00
2622424 | 00
2622539 | 00
2622584 | 00
2622597 | 00
2622647 | 00
2622725 | 00
2622744 | 00
2622771 | 00
2622790 | 00
2622821 | 00
2622835 | 00
2622852 | 00
2622890 | 00
2632421 | 01
2635864 | 00
2635951 | 00
2635971 | 00
2636045 | 00
2636107 | 00
2807462 | 01
2807504 | 01
2808945 | 00
2809071 | 00
2879872 | 01

# IfcFlowTerminal: NLRS_57_AIR_UN_deurspleet retour_gen_ISR:standaard (46)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: standaard; sets with these values: 2
Name (NLRS_57_AIR_UN_deurspleet retour_gen_ISR:standaard:...) | In
2622047 | 01
2622054 | 01
2622061 | 01
2622075 | 01
2622082 | 01
2622089 | 01
2622096 | 01
2622103 | 01
2622110 | 01
2622117 | 01
2622124 | 01
2622131 | 01
2622138 | 01
2622145 | 01
2622152 | 01
2622159 | 01
2622182 | 00
2622310 | 00
2622327 | 00
2622357 | 00
2622372 | 00
2622391 | 00
2622423 | 00
2622538 | 00
2622583 | 00
2622596 | 00
2622646 | 00
2622724 | 00
2622743 | 00
2622770 | 00
2622789 | 00
2622820 | 00
2622834 | 00
2622851 | 00
2622889 | 00
2632420 | 01
2635863 | 00
2635950 | 00
2635970 | 00
2636044 | 00
2636106 | 00
2807461 | 01
2807503 | 01
2808944 | 00
2809070 | 00
2879871 | 01

# IfcFlowTerminal: NLRS_57_AIR_UN_geperforeerde plafondplaat_gen_ISR:plaatrooster in-/uitlaat (67)
Type - Classification: 3A(57) (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: plaatrooster in-/uitlaat; sets with these values: 2
Name (NLRS_57_AIR_UN_geperforeerde plafondplaat_gen_ISR:plaatrooster in-/uitlaat:...) | In
2730484 | 01
2731039 | 01
2731061 | 01
2731115 | 01
2731146 | 01
2731167 | 01
2731185 | 01
2731205 | 01
2731267 | 01
2731301 | 01
2731329 | 01
2731415 | 01
2731431 | 01
2731465 | 01
2731481 | 01
2731497 | 01
2731541 | 01
2731575 | 01
2731591 | 01
2731904 | 01
2731922 | 01
2731944 | 01
2731964 | 01
2731996 | 01
2732107 | 01
2732129 | 01
2732192 | 01
2732271 | 00
2732450 | 00
2732484 | 00
2732494 | 00
2732526 | 00
2732536 | 00
2732570 | 00
2732578 | 00
2732620 | 00
2732658 | 00
2732670 | 00
2732678 | 00
2732696 | 00
2732710 | 00
2732718 | 00
2732798 | 00
2732832 | 00
2732871 | 00
2732913 | 00
2732939 | 00
2732940 | 00
2732948 | 00
2732949 | 00
2733073 | 00
2733107 | 00
2733131 | 00
2733181 | 00
2733205 | 00
2733255 | 00
2733267 | 00
2733275 | 00
2733337 | 00
2733387 | 00
2733395 | 00
2733443 | 00
2733488 | 00
2873475 | 01
2873511 | 00
2873708 | 00
2922358 | 01

# IfcFlowTerminal: NLRS_57_AIR_UN_retour recht_gen_ISR:standaard (3)
In: 01
Type - Classification: 3A(57) (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: standaard; sets with these values: 2
Name (NLRS_57_AIR_UN_retour recht_gen_ISR:standaard:...)
2862628
2876398
2876595

# IfcFlowTerminal: NLRS_57_AIR_UN_retour rond_gen_ISR1:standaard 2 (36)
Type - Classification: 3A(57) (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: standaard 2; sets with these values: 2
Name (NLRS_57_AIR_UN_retour rond_gen_ISR1:standaard 2:...) | In | Group
1146354 | 00 | mvr 5
1146710 | 01 | mvr 5
1154548 | 01 | mvr 5
1160457 | 01 | mvr 5
1340579 | 00 | mvr 5
1362491 | 01 | mvr 5
1363754 | 01 | mvr 5
1385227 | 00 | mvr 5
1390668 | 01 | mvr 5
1441585 | 01 | mvr 5
1456967 | 00 | mvr 5
1459500 | 00 | mvr 5
1555596 | 01 | mvr 5
1613527 | 01 | mvr 5
1678606 | 01 | mvr 5
1682624 | 01 | mvr 5
1683124 | 01 | mvr 5
1720156 | 00 | mvr 5
1727632 | 00 | mvr 5
1731816 | 00 | mvr 5
1734414 | 00 | mvr 5
1943312 | 00 | mvr 5
1994360 | 01 | mvr 5
2154168 | 00 | mvr 5
2182231 | 01 | mvr 5
2182473 | 01 | mvr 5
2315085 | 00 | mvr 5
2325705 | 00 | mvr 5
2575645 | 00 | mvr 5
2578390 | 00 | mvr 5
2581345 | 00 | mvr 5
2583216 | 00 | mvr 5
2583979 | 00 | mvr 5
2600744 | 01 | mvr 5
2629880 | 01 | mvr 5
2922160 | 01 | mvr 1

# IfcFlowTerminal: NLRS_57_AIR_UN_retour rond_gen_ISR:standaard (7)
Type - Classification: 3A(57) (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: standaard; sets with these values: 2
Group: mvr 5
Name (NLRS_57_AIR_UN_retour rond_gen_ISR:standaard:...) | In
1676818 | 00
2212256 | 01
2212464 | 01
2225340 | 00
2231188 | 00
2338588 | 00
2606310 | 02

# IfcFlowTerminal: NLRS_57_AIR_UN_toevoer recht_gen_ISR:standaard (4)
In: 01
Type - Classification: 3A(57) (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: standaard; sets with these values: 2
Name (NLRS_57_AIR_UN_toevoer recht_gen_ISR:standaard:...) | Group
2876813 | mvt 9
2877232 | mvt 7
2877358 | mvt 8
2877493 | mvt 3

# IfcFlowTerminal: NLRS_57_AIR_WPB_rooster toevoer_gen:rooster_160 (5)
In: 00
Type - Classification: 57.00 (Uniformat); Material: <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: rooster_160; sets with these values: 2
Group: mvt lbk1
Name (NLRS_57_AIR_WPB_rooster toevoer_gen:rooster_160:...) | Material
1311501
1311516 | <Unnamed>
1385980
1385981 | <Unnamed>
2077947 | <Unnamed>

# IfcFlowTerminal: NLRS_57_AIR_WPB_rooster toevoer_gen:rooster_250 (66)
Type - Classification: 57.00 (Uniformat); Material: <Unnamed> (3)
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: rooster_250; sets with these values: 2
Name (NLRS_57_AIR_WPB_rooster toevoer_gen:rooster_250:...) | In | Group | Material
1146386 | 00 | mvt lbk1
1146387 | 00 | mvt lbk1 | <Unnamed>
1146698 | 01 | mvt lbk1 | <Unnamed>
1146699 | 01 | mvt lbk1 | <Unnamed>
1154415 | 01 | mvt lbk1
1154451 | 01 | mvt lbk1
1154510 | 01 | mvt lbk1
1159598 | 01 | mvt lbk1 | <Unnamed>
1159599 | 01 | mvt lbk1 | <Unnamed>
1159659 | 01 | mvt lbk1 | <Unnamed>
1159660 | 01 | mvt lbk1 | <Unnamed>
1160456 | 01 | mvt lbk1 | <Unnamed>
1300411 | 01 | mvt lbk1
1300412 | 01 | mvt lbk1 | <Unnamed>
1301486 | 01 | mvt lbk1 | <Unnamed>
1302161 | 01 | mvt lbk1
1305878 | 00 | mvt lbk1 | <Unnamed>
1305879 | 00 | mvt lbk1 | <Unnamed>
1306071 | 00 | mvt lbk1
1306076 | 00 | mvt lbk1 | <Unnamed>
1309800 | 00 | mvt lbk1 | <Unnamed>
1310518 | 00 | mvt lbk1
1310519 | 00 | mvt lbk1 | <Unnamed>
1311757 | 00 | mvt lbk1
1311758 | 00 | mvt lbk1 | <Unnamed>
1312829 | 00 | mvt lbk1 | <Unnamed>
1312899 | 00 | mvt lbk1
1312904 | 00 | mvt lbk1 | <Unnamed>
1312911 | 00 | mvt lbk1 | <Unnamed>
1312916 | 00 | mvt lbk1 | <Unnamed>
1347625 | 00 | mvt lbk1 | <Unnamed>
1347626 | 00 | mvt lbk1 | <Unnamed>
1385983 | 00 | mvt lbk1 | <Unnamed>
1456970 | 00 | mvt lbk1
1456971 | 00 | mvt lbk1 | <Unnamed>
1509416 | 00 | mvt lbk1 | <Unnamed>
1509417 | 00 | mvt lbk1 | <Unnamed>
1532192 | 00 | mvt lbk1 | <Unnamed>
1532193 | 00 | mvt lbk1 | <Unnamed>
1532284 | 00 | mvt lbk1 | <Unnamed>
1532285 | 00 | mvt lbk1 | <Unnamed>
1570709 | 00 | mvt lbk1 | <Unnamed>
1570786 | 00 | mvt lbk1 | <Unnamed>
1571129 | 01 | mvt lbk1
1571175 | 01 | mvt lbk1 | <Unnamed>
1577626 | 01 | mvt lbk1 | <Unnamed>
2002199 | 01 | mvt lbk1 | <Unnamed>
2002200 | 01 | mvt lbk1 | <Unnamed>
2002523 | 01 | mvt lbk1
2002524 | 01 | mvt lbk1 | <Unnamed>
2323450 | 00 | mvt lbk1
2323451 | 00 | mvt lbk1 | <Unnamed>
2436173 | 01 | mvt 2
2436175 | 01 | mvt 2 | <Unnamed>
2436176 | 01 | mvt 2 | <Unnamed>
2436177 | 01 | mvt 2 | <Unnamed>
2436178 | 01 | mvt 2 | <Unnamed>
2436179 | 01 | mvt 2 | <Unnamed>
2436218 | 01 | mvt 2 | <Unnamed>
2436219 | 01 | mvt 2 | <Unnamed>
2526938 | 00 | mvt lbk1
2527015 | 00 | mvt lbk1 | <Unnamed>
2527074 | 00 | mvt lbk1 | <Unnamed>
2528111 | 00 | mvt lbk1 | <Unnamed>
2528355 | 00 | mvt lbk1 | <Unnamed>
2529198 | 00 | mvt lbk1

# IfcFlowTerminal: NLRS_57_AT_LB_toevoer_Buitenluchtrooster_SmitsAir_BA:BA-70 (5)
In: 01
Type - Material: <Unnamed> (2)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Smitsair
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: BA-70; sets with these values: 2
Name (NLRS_57_AT_LB_toevoer_Buitenluchtrooster_SmitsAir_BA:BA-70:...) | Group
2415688 | mvaz 3
2695064 | mvaz 5 | Material: <Unnamed>
2695268 | mvaf 1
2720315
2720517 | Material: <Unnamed>

# IfcFlowTerminal: NLRS_57_AT_LB_toevoer_Wandrooster_Trox_TG:TG-DG (6)
In: 01
Type - Material: <Unnamed> (2)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Trox
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: TG-DG; sets with these values: 2
Name (NLRS_57_AT_LB_toevoer_Wandrooster_Trox_TG:TG-DG:...) | Group
2430007 | mvt 4
2484002 | mvt 5 | Material: <Unnamed>
2484457 | mvt 11 | Material: <Unnamed>
2484459 | mvt 10 | Material: <Unnamed>
2484866 | mvr 2
2485495 | mvr 6

# IfcFlowTerminal: NLRS_57_AT_UN_rozet afzuig:kanaal_100 (27)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: kanaal_100; sets with these values: 2
Group: mvr 5
Name (NLRS_57_AT_UN_rozet afzuig:kanaal_100:...) | In
1305716 | 00
1305748 | 00
1329682 | 00
1334173 | 00
1423524 | 01
1423554 | 01
1423580 | 01
1456594 | 00
1480571 | 00
1480605 | 00
1489078 | 01
1489213 | 01
1489423 | 01
1489433 | 01
1492452 | 01
1494647 | 00
1494650 | 00
1600998 | 01
1606517 | 01
1606959 | 01
1692402 | 01
1692404 | 01
1996865 | 01
2050111 | 01
2050127 | 01
2050436 | 01
2163854 | 01

# IfcFlowTerminal: NLRS_57_AT_UN_rozet afzuig:kanaal_125 (17)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: kanaal_125; sets with these values: 2
Group: mvr 5
Name (NLRS_57_AT_UN_rozet afzuig:kanaal_125:...) | In
1153867 | 01
1154973 | 01
1154976 | 01
1155265 | 01
1164516 | 01
1310812 | 00
1310979 | 00
1330618 | 00
1330820 | 00
1331016 | 00
1427783 | 01
1464164 | 00
1558341 | 01
1725283 | 00
1757990 | 01
2217804 | 00
2612594 | 00

# IfcFlowTerminal: NLRS_57_AT_UN_rozet afzuig:kanaal_160 (16)
In: 00
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: kanaal_160; sets with these values: 2
Group: mvr 5
Name (NLRS_57_AT_UN_rozet afzuig:kanaal_160:...)
1311095
1311111
1311228
1311247
1311683
1456965
1457153
1459996
1460146
1496238
1496438
1496498
1496514
2320118
2576826
2576834

# IfcFlowTerminal: NLRS_57_AT_UN_rozet afzuig:kanaal_200 (5)
In: 00
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: kanaal_200; sets with these values: 2
Group: mvr 5
Name (NLRS_57_AT_UN_rozet afzuig:kanaal_200:...)
1456966
1457190
1457477
1459367
2320119

# IfcFlowTerminal: NLRS_57_AT_UN_rozet toevoer:kanaal_125 (7)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: kanaal_125; sets with these values: 2
Name (NLRS_57_AT_UN_rozet toevoer:kanaal_125:...) | In | Group
2436174 | 01 | mvt 2
2436238 | 01 | mvt 2
2609699 | 00 | mvt lbk1
2610142 | 00 | mvt lbk1
2610158 | 00 | mvt lbk1
2610187 | 00 | mvt lbk1
2617078 | 01 | mvt 2

# IfcFlowTerminal: NLRS_57_AT_UN_rozet toevoer:kanaal_160 (3)
In: 00
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: kanaal_160; sets with these values: 2
Group: mvt lbk1
Name (NLRS_57_AT_UN_rozet toevoer:kanaal_160:...)
1456968
1457154
2323448

# IfcFlowTerminal: NLRS_57_AT_UN_rozet toevoer:kanaal_200 (3)
In: 00
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: kanaal_200; sets with these values: 2
Group: mvt lbk1
Name (NLRS_57_AT_UN_rozet toevoer:kanaal_200:...)
1456969
1457191
2323449

# IfcFlowTerminal: NLRS_74_PF_UN_asp riolering:Aansluitpunt Badmeubel (3)
In: 00
Type - Material: PVC grijs
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Aansluitpunt Badmeubel; sets with these values: 2
Group: vwa 1
Name (NLRS_74_PF_UN_asp riolering:Aansluitpunt Badmeubel:...)
2473620
2474256
2474800

# IfcFlowTerminal: NLRS_74_PF_UN_asp riolering:Aansluitpunt Doucheruimte (3)
In: 01
Type - Material: PVC grijs
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Aansluitpunt Doucheruimte; sets with these values: 2
Group: vwa 1
Name (NLRS_74_PF_UN_asp riolering:Aansluitpunt Doucheruimte:...)
2299334
2299777
2475672

# IfcFlowTerminal: NLRS_74_PF_UN_asp riolering:Aansluitpunt aanrecht (9)
Type - Material: PVC grijs
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Aansluitpunt aanrecht; sets with these values: 2
Group: vwa 1
Name (NLRS_74_PF_UN_asp riolering:Aansluitpunt aanrecht:...) | In
1619982 | 00
1620380 | 00
1620831 | 00
1620855 | 00
1941466 | 00
2298201 | 00
2456015 | 00
2566115 | 01
2566366 | 01

# IfcFlowTerminal: NLRS_74_PF_UN_asp riolering:Aansluitpunt condensafvoer (4)
In: 00
Type - Material: PVC grijs
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Aansluitpunt condensafvoer; sets with these values: 2
Name (NLRS_74_PF_UN_asp riolering:Aansluitpunt condensafvoer:...) | Group
2854797 | vwa 1
2855205 | vwa 9
2855267 | vwa 9
2855303 | vwa 9

# IfcFlowTerminal: NLRS_74_PF_UN_asp riolering:Aansluitpunt wasmacine, NLRS_74_PF_UN_asp riolering:Aansluitpunt wasmacine:2292590
In: 00
Type - Material: PVC grijs
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Aansluitpunt wasmacine; sets with these values: 2
Group: vwa 1

# IfcFlowTerminal: NLRS_74_PF_UN_asp riolering:Aansluitpunt wastafel (27)
Type - Material: PVC grijs
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: Aansluitpunt wastafel; sets with these values: 2
Group: vwa 1
Name (NLRS_74_PF_UN_asp riolering:Aansluitpunt wastafel:...) | In
1550131 | 01
1550302 | 01
1558883 | 01
1619926 | 00
1620156 | 00
1620177 | 00
1620217 | 00
1620234 | 00
1941546 | 01
1941589 | 01
2048039 | 00
2288141 | 00
2293660 | 00
2293719 | 00
2294357 | 01
2294409 | 01
2296666 | 01
2296925 | 01
2297343 | 01
2297508 | 00
2297934 | 00
2298556 | 00
2298577 | 00
2298799 | 00
2475597 | 01
2475641 | 01
2523917 | 00

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_dubbel:Aanrecht (4)
In: 00
Type - Material: Sparing, messing, ISR_messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: ISR_messing
Pset_DistributionFlowElementCommon - Reference: Aanrecht; sets with these values: 2
Name (NLRS_74_PF_UN_tappunt_dubbel:Aanrecht:...) | Group
2286065 | kw 3
2286399 | kw 3
2286428 | kw 3
2286485 | ww 3; kw 3

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_dubbel:Aanrecht, NLRS_74_PF_UN_tappunt_dubbel:Aanrecht:2566490
In: 01
Type - Material: messing, Sparing, ISR_messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: ISR_messing; Group: ww 12; kw 3
Pset_DistributionFlowElementCommon - Reference: Aanrecht; sets with these values: 2

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_dubbel:Douche, NLRS_74_PF_UN_tappunt_dubbel:Douche:2476778
In: 01
Type - Material: Sparing, messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: messing; Group: kw 3
Pset_DistributionFlowElementCommon - Reference: Douche; sets with these values: 2

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_dubbel:Wastafel (10)
Type - Material: Sparing, messing, ISR_messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: ISR_messing
Pset_DistributionFlowElementCommon - Reference: Wastafel; sets with these values: 2
Name (NLRS_74_PF_UN_tappunt_dubbel:Wastafel:...) | In | Group
2279349 | 01 | ww 5; kw 3
2280221 | 01 | kw 3
2280778 | 00 | ww 2; kw 3
2283712 | 00 | ww 5; kw 3
2283730 | 00 | ww 3; kw 3
2473692 | 00 | ww 1; kw 3
2474739 | 00 | ww 2; kw 3
2474767 | 00 | ww 2; kw 3
2785761 | 01 | ww 4; kw 3
2795363 | 00 | ww 7; kw 3

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_enkel:Brandslanghaspel (5)
Type - Material: Sparing, messing, ISR_messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: ISR_messing; Group: kw BSH
Pset_DistributionFlowElementCommon - Reference: Brandslanghaspel; sets with these values: 2
Name (NLRS_74_PF_UN_tappunt_enkel:Brandslanghaspel:...) | In
2535754 | 01
2537545 | 01
2538224 | 00
2538609 | 00
2538669 | 00

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_enkel:Fontein (14)
Type - Material: Sparing, messing, ISR_messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: ISR_messing; Group: kw 3
Pset_DistributionFlowElementCommon - Reference: Fontein; sets with these values: 2
Name (NLRS_74_PF_UN_tappunt_enkel:Fontein:...) | In
2277587 | 01
2278790 | 01
2278910 | 01
2279252 | 01
2283548 | 00
2284396 | 00
2284438 | 00
2284467 | 00
2287801 | 00
2288516 | 00
2288564 | 00
2288596 | 00
2288640 | 00
2565826 | 01

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_enkel:Fontein (6)
Type - Material: messing, Sparing, ISR_messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: ISR_messing; Group: kw 3
Pset_DistributionFlowElementCommon - Reference: Fontein; sets with these values: 2
Name (NLRS_74_PF_UN_tappunt_enkel:Fontein:...) | In
2277866 | 01
2281038 | 00
2282609 | 00
2283764 | 00
2292561 | 01
2523912 | 00

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_enkel:Technische ruimte, NLRS_74_PF_UN_tappunt_enkel:Technische ruimte:2288869
In: 00
Type - Material: messing, Sparing, ISR_messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: ISR_messing; Group: kw 3
Pset_DistributionFlowElementCommon - Reference: Technische ruimte; sets with these values: 2

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_enkel:Toilet (8)
Type - Material: Sparing, messing, ISR_messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: ISR_messing; Group: kw 3
Pset_DistributionFlowElementCommon - Reference: Toilet; sets with these values: 2
Name (NLRS_74_PF_UN_tappunt_enkel:Toilet:...) | In
2277498 | 01
2277501 | 01
2278568 | 01
2285302 | 00
2289888 | 01
2289920 | 01
2289952 | 01
2289982 | 01

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_enkel:Toilet (32)
Type - Material: messing, Sparing, ISR_messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: ISR_messing
Pset_DistributionFlowElementCommon - Reference: Toilet; sets with these values: 2
Name (NLRS_74_PF_UN_tappunt_enkel:Toilet:...) | In | Group
2277525 | 01 | kw 3
2277528 | 01 | kw 3
2278573 | 01 | kw 3
2278617 | 01 | kw 3
2278635 | 01 | kw 3
2278653 | 01 | kw 3
2278669 | 01 | kw 3
2278685 | 01 | kw 3
2280762 | 00 | kw 3
2282436 | 00 | kw 3
2283243 | 00 | kw 3
2283288 | 00 | kw 3
2283310 | 00 | kw 3
2284352 | 00 | kw 3
2284357 | 00 | kw 3
2285904 | 00 | kw 3
2285909 | 00 | kw 3
2287276 | 00 | kw 3
2287296 | 00 | kw 3
2287341 | 00 | kw 53
2287371 | 00 | kw 3
2287376 | 00 | kw 3
2287381 | 00 | kw 3
2287409 | 00 | kw 55
2288795 | 00 | kw 3
2288800 | 00 | kw 3
2288829 | 00 | kw 3
2288834 | 00 | kw 3
2289893 | 01 | kw 3
2289925 | 01 | kw 3
2289957 | 01 | kw 3
2289987 | 01 | kw 3

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_enkel:Wasmachine, NLRS_74_PF_UN_tappunt_enkel:Wasmachine:2287067
In: 00
Type - Material: Sparing, messing, ISR_messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: ISR_messing; Group: kw 3
Pset_DistributionFlowElementCommon - Reference: Wasmachine; sets with these values: 2

# IfcFlowTerminal: NLRS_74_PF_UN_tappunt_enkel:Wastafel toiletgroep/leerplein (6)
Type - Material: Sparing, messing, ISR_messing
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: ISR_messing; Group: kw 3
Pset_DistributionFlowElementCommon - Reference: Wastafel toiletgroep/leerplein; sets with these values: 2
Name (NLRS_74_PF_UN_tappunt_enkel:Wastafel toiletgroep/leerplein:...) | In
2279061 | 01
2279082 | 01
2279119 | 01
2279151 | 01
2280769 | 00
2284772 | 00

# IfcFlowTerminal: NLRS_74_PF_WPB_bedieningsplaat Sigma 50_Geberit:gr/kl spoeling melkglas groen (40)
Type - Material: chroom mat (2), satijnglas groen
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: gr/kl spoeling melkglas groen; sets with these values: 2
Name (NLRS_74_PF_WPB_bedieningsplaat Sigma 50_Geberit:gr/kl spoeling melkglas groen:...) | In | Material
1409138 | 01
1410147 | 01 | chroom mat, satijnglas groen
1410199 | 01 | chroom mat, satijnglas groen
1410217 | 01 | chroom mat, satijnglas groen
1410237 | 01 | chroom mat, satijnglas groen
1410257 | 01 | chroom mat, satijnglas groen
1410293 | 01 | chroom mat, satijnglas groen
1410324 | 01 | chroom mat, satijnglas groen
1410360 | 01 | chroom mat, satijnglas groen
1410368 | 01 | chroom mat, satijnglas groen
1411386 | 01
1411394 | 01 | chroom mat, satijnglas groen
1411402 | 01 | chroom mat, satijnglas groen
1411410 | 01 | chroom mat, satijnglas groen
1411418 | 01 | chroom mat, satijnglas groen
1546236 | 01 | chroom mat, satijnglas groen
1546397 | 01 | chroom mat, satijnglas groen
1617265 | 00 | chroom mat, satijnglas groen
1618080 | 00 | chroom mat, satijnglas groen
1618172 | 00 | chroom mat, satijnglas groen
1618196 | 00 | chroom mat, satijnglas groen
1618204 | 00 | chroom mat, satijnglas groen
1618212 | 00 | chroom mat, satijnglas groen
1618302 | 00 | chroom mat, satijnglas groen
1618310 | 00 | chroom mat, satijnglas groen
1618318 | 00 | chroom mat, satijnglas groen
1618433 | 00 | chroom mat, satijnglas groen
1618462 | 00 | chroom mat, satijnglas groen
1619041 | 00 | chroom mat, satijnglas groen
1619107 | 00 | chroom mat, satijnglas groen
2042967 | 01 | chroom mat, satijnglas groen
2043270 | 01 | chroom mat, satijnglas groen
2046962 | 00 | chroom mat, satijnglas groen
2046993 | 00 | chroom mat, satijnglas groen
2047776 | 00 | chroom mat, satijnglas groen
2120246 | 00 | chroom mat, satijnglas groen
2120898 | 00 | chroom mat, satijnglas groen
2122099 | 00 | chroom mat, satijnglas groen
2122107 | 00 | chroom mat, satijnglas groen
2122115 | 00 | chroom mat, satijnglas groen

# IfcFlowTerminal: NLRS_74_PF_WPB_duofix H112 sigma 12cm_Geberit1:std (40)
Type - Classification: 4A(74.11) (Uniformat); Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Geberit
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Material: <Unnamed>, Laminate, Ivory, Matte, Laminate, Navy, Plastic, Opaque Black, Steel, Paint Finish, Blue; Group: vwa 1
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_74_PF_WPB_duofix H112 sigma 12cm_Geberit1:std:...) | In
1409137 | 01
1410146 | 01
1410198 | 01
1410216 | 01
1410236 | 01
1410256 | 01
1410292 | 01
1410323 | 01
1410359 | 01
1410367 | 01
1411385 | 01
1411393 | 01
1411401 | 01
1411409 | 01
1411417 | 01
1546235 | 01
1546396 | 01
1617264 | 00
1618079 | 00
1618171 | 00
1618195 | 00
1618203 | 00
1618211 | 00
1618301 | 00
1618309 | 00
1618317 | 00
1618432 | 00
1618461 | 00
1619040 | 00
1619106 | 00
2042966 | 01
2043269 | 01
2046961 | 00
2046992 | 00
2047775 | 00
2120245 | 00
2120897 | 00
2122098 | 00
2122106 | 00
2122114 | 00

# IfcFlowTreatmentDevice: NLRS_57_DA_UN_nakoeler rond_solidair_ac-r:L500_D200 (6)
In: 00
Type - Description: Nakoeler; PredefinedType: ROUND; Classification: 3A(57) (Uniformat); Material: NLRS_A_staal Sendzimir verzinkt
Type - Pset_ManufacturerTypeInformation - Manufacturer: n.t.b.
Type - Pset_ProductRequirements - Category: Duct Accessories
Material: NLRS_A_staal Sendzimir verzinkt, <Unnamed>
Pset_DistributionFlowElementCommon - Reference: L500_D200; sets with these values: 2
Name (NLRS_57_DA_UN_nakoeler rond_solidair_ac-r:L500_D200:...) | Group
2709611 | gkwa 3; vwa 5; vwa 2; gkwr 2; mvt lbk1
2710792 | cvr 4; gkwa 3; mvt lbk1
2711550 | gkwa 3; gkwr 2; mvt lbk1
2714044 | gkwa 3; gkwr 2; mvt lbk1
2714923 | gkwa 3; gkwr 2; mvt lbk1
2714924 | gkwa 3; gkwr 2; mvt lbk1

# IfcFlowTreatmentDevice: NLRS_57_DUA_UN_geluiddemper rechth_gen_ISR:L1500 (8)
Type - Description: Geluiddemper, rechthoekig, coulisse, Sendzimir verzinkt staal; PredefinedType: RECTANGULAR; Classification: 3A(57) (Uniformat); Material: NLRS_A_staal Sendzimir verzinkt (3)
Type - Pset_ManufacturerTypeInformation - Manufacturer: n.t.b.
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_DistributionFlowElementCommon - Reference: L1500; sets with these values: 2
Name (NLRS_57_DUA_UN_geluiddemper rechth_gen_ISR:L1500:...) | In | Length (mm) | Group
1104700 | 01 | 1530 | mvr 5
1520179 | 01 |  | mvaz 1 | Material: NLRS_A_staal Sendzimir verzinkt
1789962 | 01 |  | mvaf 5 | Material: NLRS_A_staal Sendzimir verzinkt
1827225 | 01 | 1530 | mvt lbk1
2428432 | 01 | 700 | mvt lbk1
2700733 | 02 | 612 | mvaf 6
2702178 | 02 | 612 | mvaz 6
2705620 | 02 |  | mvt 2 | Material: NLRS_A_staal Sendzimir verzinkt

# IfcOpeningElement: Opening, 350_57_rechth_verloopbocht_a_Luka:verzinkt_staal:2708021:1
In: 02
Classification: 3A(57.55) (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Luka
Pset_OpeningElementCommon - Reference: verzinkt_staal; sets with these values: 2
Pset_ProductRequirements - Category: Duct Fittings
