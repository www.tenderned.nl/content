Properties of the parts of a building model (IFC2X3), part 12 of 13

# IfcFlowSegment: Pipe Types:NLRS_50_PI_UN_Staal - lasverbinding Lasleiding_gen_ISR (148)
Name (Pipe Types:NLRS_50_PI_UN_Staal - lasverbinding Lasleiding_gen_ISR:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1270938 | 178.923 | 167.55 | cvr 3
1271408 | 714.35 | 298 | cvr 3
1271456 | 128 | 1303 | cva 3
1273163 | 154.561 | 167.55 | cvr 3
1274075 | 3261.94 | 395.401 | cvr 7 (1)
1274081 | 3261.94 | 136.75 | gkwr 1
1274356 | 85.15 | 38 | gkwr 1
1274362 | 2.67699 | 120.473 | gkwr 1
1274366 | 89 | 81.173 | gkwr 1
1274371 | 32.677 | 349.124 | cvr 7 (1)
1274373 | 89 | 309.824 | cvr 7 (1)
1274422 | 343.801 | 38 | cvr 7 (1)
1275289 | 85.15 | 38 | gkwr 1
1275362 | 343.801 | 38 | cvr 7 (1)
1275381 | 85.15 | 38 | gkwr 1
1275412 | 343.801 | 38 | cvr 7 (1)
1275878 | 3261.94 | 395.401 | cva 5
1275884 | 3261.94 | 136.75 | cva 5; gkwa 2
1275890 | 85.15 | 38 | gkwa 2
1275896 | 2.67699 | 120.473 | gkwa 2
1275900 | 89 | 81.173 | gkwa 2
1275905 | 32.677 | 349.124 | cva 5
1275907 | 89 | 309.824 | cva 5
1275914 | 343.801 | 38 | cva 5
1275920 | 85.15 | 38 | gkwa 2
1275926 | 343.801 | 38 | cva 5
1275932 | 85.15 | 38 | gkwa 2
1275938 | 343.801 | 38 | cva 5
1277330 | 1323.7 | 737.952 | cvr 7 (1); gkwr 1
1277517 | 459.65 | 514.151 | gkwr 1
1278564 | 1977 | 1303 | cva 5
1278594 | 151.542 | 167.55 | cvr 7 (1)
1278600 | 2982 | 298 | cvr 7 (1)
1278855 | 105.458 | 167.55 | cvr 7 (1)
1278989 | 92.45 | 1172.55 | cva 5
1279231 | 3029.94 | 3339.55 | cvr 7 (1)
1279272 | 3161.56 | 3339.55 | cva 5
1279576 | 838.336 | 3339.55 | cva 5
1279608 | 2723.35 | 556.651 | cva 5
1279638 | 688.336 | 3339.55 | cvr 7 (1)
1280089 | 265.727 | 426.201 | cva 5
1280544 | 2982 | 298 | gkwa 2
1280640 | 265 | 167.55 | gkwr 1
1280648 | 2982 | 298 | gkwr 1
1280846 | 1249.06 | 3339.55 | gkwa 2
1281664 | 1429.88 | 3339.55 | gkwr 1
1281796 | 21 | 808.45 | gkwr 1
1281840 | 2225.5 | 1054.5 | gkwr 1
1281860 | 1288.97 | 3339.55 | gkwr 1
1281887 | 1156.03 | 3339.55 | gkwa 2
1281895 | 2985 | 294.986 | gkwa 2
1282376 | 36.7924 | 126.076 | gkwa 2
1282516 | 130.613 | 158.45 | gkwa 2
1283501 | 2723.35 | 556.651 | cvr 7 (1)
1284071 | 131.301 | 277.85 | gkwr 1
1284157 | 96.4503 | 536.501 | cvr 7 (1)
1284603 | 138.85 | 1022.25 | gkwr 1
1285376 | 24.85 | 827.6 | cvr 7 (1)
1285439 | 24.85 | 827.6 | gkwr 1
1285966 | 1323.7 | 737.952 | cvr 7 (1)
1285968 | 459.65 | 514.151 | gkwr 1
1285971 | 131.301 | 277.85 | gkwr 1
1285974 | 96.4503 | 536.501 | cvr 7 (1)
1285976 | 138.85 | 1022.25 | gkwr 1
1285983 | 24.85 | 827.6 | cvr 7 (1)
1285988 | 24.85 | 827.6 | gkwr 1
1286029 | 1323.7 | 737.952 | cvr 7 (1); gkwr 1
1286031 | 459.65 | 514.151 | gkwr 1
1286034 | 131.301 | 277.85 | gkwr 1
1286037 | 96.4503 | 536.501 | cvr 7 (1)
1286039 | 138.85 | 1022.25 | gkwr 1
1286046 | 24.85 | 827.6 | cvr 7 (1)
1286051 | 24.85 | 827.6 | gkwr 1
1286119 | 1323.7 | 737.952 | cvr 7 (1)
1286121 | 459.65 | 514.151 | gkwr 1
1286124 | 131.301 | 277.85 | gkwr 1
1286127 | 96.4503 | 536.501 | cvr 7 (1)
1286129 | 138.85 | 1022.25 | gkwr 1
1286136 | 24.85 | 827.6 | cvr 7 (1)
1286141 | 24.85 | 827.6 | gkwr 1
1286378 | 1323.7 | 737.952 | cva 5
1286380 | 459.65 | 514.151 | cva 5
1286383 | 131.301 | 277.85 | cva 5
1286386 | 96.4503 | 536.501 | cva 5
1286388 | 138.85 | 1022.25 | cva 5
1286395 | 24.85 | 827.6 | cva 5
1286400 | 24.85 | 827.6 | cva 5
2737925 | 1480.57 | 1150.35 | cvr 3
2738271 | 1156.92 | 1569 | cva 3
2740688 | 777 | 2690.47 | cvr 3
2740716 | 330.305 | 2785.47 | cva 3
2743692 | 231.364 | 1011.78 | brr 1
2743715 | 1323.7 | 737.952 | cva 2
2743717 | 459.65 | 514.151 | cva 2
2743720 | 131.301 | 277.85 | cva 2
2743723 | 96.4503 | 536.501 | cva 2
2743725 | 138.85 | 1022.25 | cva 2
2743732 | 24.85 | 897.6 | cva 2
2743737 | 24.85 | 827.6 | cva 2
2743752 | 1323.7 | 737.952 | cva 9
2743754 | 459.65 | 514.151 | cva 9
2743757 | 131.301 | 277.85 | cva 9
2743760 | 96.4503 | 536.501 | cva 9
2743762 | 138.85 | 1022.25 | cva 9
2743769 | 24.85 | 897.6 | cva 9
2743774 | 24.85 | 827.6 | cva 9
2743791 | 1323.7 | 737.952 | cva 11
2743793 | 459.65 | 514.151 | cva 11
2743796 | 131.301 | 277.85 | cva 11
2743799 | 96.4503 | 536.501 | cva 11
2743801 | 138.85 | 1022.25 | cva 11
2743808 | 24.85 | 897.6 | cva 11
2743813 | 24.85 | 827.6 | cva 11
2912198 | 748 | 3162.47 | brr 1
2912210 | 828 | 2969.4 | bra 3
2912222 | 2098.09 | 2969.4 | bra 3
2912234 | 828 | 3148.47 | brr 1
2912352 | 777 | 2785.47 | cva 3
2912907 | 848 | 2785.47 | cva 3
2912921 | 1193.14 | 2785.47 | cva 3
2912986 | 848 | 2690.47 | cvr 3
2912998 | 1810.69 | 2690.47 | cvr 3

# IfcFlowSegment: Pipe Types:NLRS_50_PI_UN_Staal - lasverbinding T-stuk_gen_ISR (42)
In: 00
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipes
Classification: 5- (Uniformat)
Pset_DistributionFlowElementCommon - Reference: NLRS_50_PI_UN_Staal - lasverbinding T-stuk_gen_ISR; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.046 mm
Name (Pipe Types:NLRS_50_PI_UN_Staal - lasverbinding T-stuk_gen_ISR:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1264976 | 495.129 | 2580.39 | brr 1
1264990 | 25.3999 | 2325.99 | brr 1
1264991 | 83.2017 | 2424.34 | brr 1
1268573 | 2565.87 | 509.629 | brr 1
1269047 | 1611.8 | 2026.55 | cva 6
1269093 | 1254.19 | 2144.97 | cvr 5
1269099 | 1611.8 | 2144.97 | cvr 5
1269270 | 1272.23 | 720.27 | cva 6
1269351 | 286 | 418 | cvr 5
1269510 | 1354.92 | 756 | cvr 5
2740273 | 1259.05 | 2026.55 | cva 6
2911074 | 338.418 | 1782 | cvr 5
2911185 | 220 | 1782 | cva 6
2911277 | 1026.95 | 1808 | bra 3
2911334 | 1206.02 | 1808 | brr 1
2911381 | 872.918 | 1796 | cvr 3
2911438 | 823.121 | 1796 | cva 3
2911550 | 153.197 | 2026.4 | cva 6
2911566 | 207.194 | 2144.82 | cvr 5
2911695 | 338.418 | 1782 | cvr 5
2911697 | 220 | 1782 | cva 6
2911699 | 1026.95 | 1808 | bra 3
2911703 | 1206.02 | 1808 | brr 1
2911707 | 763.918 | 1796 | cvr 3
2911711 | 823.121 | 1796 | cva 3
2911719 | 93.1969 | 2026.4 | cva 6
2911723 | 147.197 | 2144.82 | cvr 5
2911760 | 338.418 | 1782 | cvr 5
2911762 | 220 | 1782 | cva 6
2911764 | 1126.95 | 1808 | bra 3
2911768 | 1306.02 | 1808 | brr 1
2911772 | 763.918 | 1796 | cvr 3
2911776 | 823.121 | 1796 | cva 3
2911784 | 93.197 | 2026.4 | cva 6
2911788 | 147.197 | 2144.82 | cvr 5
2911815 | 864 | 2026.55 | cva 6
2911829 | 863.996 | 2144.97 | cvr 5
2911843 | 904 | 2026.55 | cva 6
2911857 | 904 | 2144.97 | cvr 5
2912717 | 171.409 | 2644.63 | cva 3
2912849 | 62.4087 | 2644.63 | cva 3
2912871 | 62.4087 | 2644.63 | cva 3

# IfcFlowSegment: Pipe Types:NLRS_52_PI_HWA_PVC BS KOMO RWA Grijs OD_Dyka (61)
Type - Description: PVC buis voor HWA met KOMO keur; PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipes
Classification: 52.10 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: NLRS_52_PI_HWA_PVC BS KOMO RWA Grijs OD_Dyka; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00303 mm
Name (Pipe Types:NLRS_52_PI_HWA_PVC BS KOMO RWA Grijs OD_Dyka:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
2498847 | 01 | 142.714 | -207 | hwa 2
2499180 | 01 | 96.669 | -792.668 | hwa 2
2499184 | 01 | 80.5786 | -923.376 | hwa 2
2499199 | 01 | 125 | -252 | hwa 2
2499201 | 01 | 517.683 | -691.11 | hwa 2
2499288 | 01 | 96.9314 | -792.93 | hwa 2
2499292 | 01 | 80.9552 | -923.713 | hwa 2
2499307 | 01 | 125 | -252 | hwa 2
2499309 | 01 | 517.683 | -691.11 | hwa 2
2499332 | 01 | 97.1862 | -793.185 | hwa 2
2499336 | 01 | 81.3447 | -924.042 | hwa 2
2499351 | 01 | 125 | -252 | hwa 2
2499353 | 01 | 517.683 | -691.11 | hwa 2
2499376 | 01 | 97.4337 | -793.433 | hwa 2
2499380 | 01 | 81.7466 | -924.362 | hwa 2
2499395 | 01 | 75 | -252 | hwa 2
2499397 | 01 | 517.683 | -691.11 | hwa 2
2499420 | 01 | 97.6747 | -793.674 | hwa 2
2499424 | 01 | 82.1615 | -924.676 | hwa 2
2499439 | 01 | 125 | -252 | hwa 2
2499441 | 01 | 517.683 | -691.11 | hwa 2
2500338 | 01 | 142.714 | -207 | hwa 2
2500368 | 01 | 142.714 | -207 | hwa 2
2500398 | 01 | 142.714 | -207 | hwa 2
2501059 | 01 | 80 | -207 | hwa 2
2501061 | 01 | 518.224 | -646.493 | hwa 2
2501102 | 01 | 80 | -207 | hwa 2
2501147 | 01 | 80 | -207 | hwa 2
2501192 | 01 | 80 | -207 | hwa 2
2503249 | 01 | 60 | -252 | hwa 2
2523463 | 02 | 3 | 8192 | hwa 1
2523532 | 02 | 52.7868 | 8081.62 | hwa 1
2523548 | 02 | 171 | 8051.95 | hwa 1
2523614 | 02 | 3 | 8192 | hwa 3
2523616 | 02 | 52.7868 | 8081.62 | hwa 3
2523622 | 02 | 171 | 8051.95 | hwa 3
2825745 | 01 | 8.17683 | -659.865 | hwa 2
2825853 | 01 | 80 | -207 | hwa 2
2825855 | 01 | 518.224 | -646.493 | hwa 2
2825863 | 01 | 8.1769 | -659.865 | hwa 2
2825984 | 01 | 516.224 | -645.079 | hwa 2
2825986 | 01 | 10.1768 | -659.865 | hwa 2
2826023 | 01 | 516.224 | -645.079 | hwa 2
2826025 | 01 | 10.1768 | -659.865 | hwa 2
2826066 | 01 | 516.224 | -645.079 | hwa 2
2826068 | 01 | 10.1768 | -659.865 | hwa 2
2885139 | 01 | 517.666 | -646.098 | hwa 2
2885145 | 01 | 8.87944 | -659.866 | hwa 2
2885856 | 01 | 517.666 | -646.098 | hwa 2
2885858 | 01 | 8.87952 | -659.866 | hwa 2
2885884 | 01 | 517.666 | -646.098 | hwa 2
2885886 | 01 | 8.8796 | -659.866 | hwa 2
2885910 | 01 | 517.666 | -646.098 | hwa 2
2885912 | 01 | 8.87968 | -659.866 | hwa 2
2886401 | 01 | 12.684 | -708.674 | hwa 2
2886403 | 01 | 201.87 | -924.47 | hwa 2
2886409 | 01 | 517.683 | -691.102 | hwa 2
2886433 | 01 | 97.6747 | -793.674 | hwa 2
2886435 | 01 | 82.1615 | -924.676 | hwa 2
2886441 | 01 | 519.683 | -691.11 | hwa 2
2889309 | 01 | 182 | -250 | hwa 2

# IfcFlowSegment: Pipe Types:NLRS_52_PI_PVC DykaSono OD_Dyka (7)
Type - PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipes
Classification: 52 (Uniformat); Group: vwa 1
Pset_DistributionFlowElementCommon - Reference: NLRS_52_PI_PVC DykaSono OD_Dyka; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00283 mm
Name (Pipe Types:NLRS_52_PI_PVC DykaSono OD_Dyka:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm)
1409157 | 01 | 618.157 | 3215.32
1410401 | 00 | 3807.61 | -891.804
1413061 | 00 | 3807.61 | -891.81
1413392 | 00 | 3612.89 | -753.211
1413868 | 00 | 4033.04 | -888.354
1546255 | 01 | 431.279 | 3402.2
1546416 | 01 | 633.737 | 3195.32

# IfcFlowSegment: Pipe Types:NLRS_52_PI_PVC U3 Grijs OD_Dyka (480)
Type - PredefinedType: RIGIDSEGMENT
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipes
Classification: 52 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: NLRS_52_PI_PVC U3 Grijs OD_Dyka; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00303 mm
Name (Pipe Types:NLRS_52_PI_PVC U3 Grijs OD_Dyka:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1409143 | 01 | 110.142 | 3877.35 | vwa 1
1409149 | 01 | 81.4746 | 3841.67 | vwa 1
1409155 | 01 | 4306.92 | 3953.47 | o 4
1409328 | 00 | 1085.43 | 3053.2 | vwa 1
1409361 | 00 | 3750.02 | -753.211 | vwa 1
1410148 | 01 | 810.683 | 3134.32 | vwa 1
1410200 | 01 | 810.683 | 3134.32 | vwa 1
1410218 | 01 | 810.683 | 3134.32 | vwa 1
1410238 | 01 | 810.683 | 3134.32 | vwa 1
1410258 | 01 | 810.683 | 3134.32 | vwa 1
1410294 | 01 | 864.683 | 3080.32 | vwa 1
1410300 | 00 | 288.548 | 2918.2 | vwa 1
1410325 | 01 | 865.341 | 3079.66 | vwa 1
1410331 | 00 | 288.548 | 2917.54 | vwa 1
1410361 | 01 | 579.683 | 3365.32 | vwa 1
1410369 | 01 | 579.683 | 3365.32 | vwa 1
1411067 | 00 | 580.037 | 2972.2 | vwa 1
1411178 | 00 | 580.037 | 2972.2 | vwa 1
1411189 | 00 | 781 | 2972.2 | vwa 1
1411214 | 00 | 580.037 | 2972.2 | vwa 1
1411223 | 00 | 781 | 2972.2 | vwa 1
1411257 | 00 | 580.037 | 2972.2 | vwa 1
1411266 | 00 | 781 | 2972.2 | vwa 1
1411387 | 01 | 810.683 | 3134.32 | vwa 1
1411395 | 01 | 810.357 | 3134.64 | vwa 1
1411403 | 01 | 810.683 | 3134.32 | vwa 1
1411411 | 01 | 810.683 | 3134.32 | vwa 1
1411419 | 01 | 810.683 | 3134.32 | vwa 1
1411473 | 00 | 642.911 | 2972.2 | vwa 1
1411491 | 00 | 642.911 | 2972.2 | vwa 1
1411493 | 00 | 781 | 2972.2 | vwa 1
1411509 | 00 | 642.911 | 2972.53 | vwa 1
1411511 | 00 | 781 | 2972.2 | vwa 1
1411527 | 00 | 641.912 | 2972.2 | vwa 1
1411529 | 00 | 781 | 2972.2 | vwa 1
1411675 | 00 | 486.533 | 2972.2 | vwa 1
1413312 | 01 | 5211.05 | 3049.35 | o 5
1413416 | 00 | 111.232 | 2916.55 | o 5
1413515 | 00 | 781.001 | 2918.2 | vwa 1
1413956 | 00 | 455.745 | 3203.2 | vwa 1
1414133 | 00 | 468.76 | 3203.2 | vwa 1
1414135 | 00 | 467.093 | 3203.2 | vwa 1
1414137 | 01 | 4895.08 | 3365.32 | o 8
1414141 | 00 | 208.162 | 3203.2 | o 8
1414152 | 00 | 779.821 | 3203.2 | vwa 1
1414249 | 00 | 624.12 | 3203.2 | vwa 1
1414702 | 00 | 2197.52 | -888.62 | vwa 1
1414704 | 00 | 4071.84 | -888.155 | vwa 1
1488851 | 00 | 2358.25 | 3242.2 | vwa 1
1546241 | 01 | 110.142 | 3877.35 | vwa 1
1546247 | 01 | 96.9593 | 3841.67 | vwa 1
1546253 | 01 | 4306.92 | 3953.47 | o 9
1546402 | 01 | 116.393 | 3872.93 | vwa 1
1546408 | 01 | 76.5697 | 3837.25 | vwa 1
1546414 | 01 | 3141.93 | 3949.05 | o 10; vwa 1
1546918 | 00 | 826.5 | 3242.2 | vwa 1
1546940 | 00 | 473.832 | 3242.2 | vwa 1
1550132 | 00 | 913.254 | 3061.75 | vwa 1
1550303 | 00 | 626.603 | 3348.4 | vwa 1
1551529 | 00 | 1607.64 | 2933.85 | vwa 1
1551774 | 00 | 296.885 | 2933.85 | vwa 1
1552022 | 00 | 437.229 | 2916.55 | vwa 1
1558884 | 00 | 794.603 | 3165.4 | vwa 1
1560024 | 01 | 644.559 | 3300.43 | vwa 1
1571629 | 01 | 3528.72 | 4731.68 | o 1
1572433 | 01 | 370.842 | 2972.2 | vwa 1
1572443 | 01 | 717.864 | 2972.2 | vwa 1
1572477 | 01 | 384.376 | 2972.2 | vwa 1
1572487 | 01 | 654.99 | 2972.2 | vwa 1
1572576 | 01 | 653.913 | 2972.2 | o 1
1572714 | 01 | 307.577 | 2972.2 | vwa 1
1572795 | 01 | 320.413 | 2972.2 | vwa 1
1573067 | 01 | 42.2897 | 4540.69 | o 1
1573076 | 01 | 1433.36 | 3134.32 | o 1
1573111 | 01 | 1393.49 | 3134.32 | o 1
1617584 | 00 | 1038.15 | -888.155 | vwa 1
1618081 | 00 | 1038.63 | -888.633 | vwa 1
1618173 | 00 | 1034.86 | -884.864 | vwa 1
1618197 | 00 | 1037.89 | -887.887 | vwa 1
1618205 | 00 | 1040.03 | -890.027 | vwa 1
1618213 | 00 | 1036.74 | -886.736 | vwa 1
1618303 | 00 | 1039.68 | -889.684 | vwa 1
1618311 | 00 | 1039.68 | -889.684 | vwa 1
1618319 | 00 | 1039.68 | -889.683 | vwa 1
1618434 | 00 | 1039.68 | -889.683 | vwa 1
1618463 | 00 | 1039.68 | -889.683 | vwa 1
1619042 | 00 | 1039.68 | -889.683 | vwa 1
1619108 | 00 | 1038.3 | -888.304 | vwa 1
1619927 | 00 | 1004.93 | -904.932 | vwa 1
1620063 | 00 | 1019.93 | -919.932 | vwa 1
1620157 | 00 | 1005.99 | -905.994 | vwa 1
1620178 | 00 | 1004.61 | -904.61 | vwa 1
1620218 | 00 | 1003.06 | -903.064 | vwa 1
1620235 | 00 | 1004.6 | -904.603 | vwa 1
1620805 | 00 | 1019.6 | -919.603 | vwa 1
1620832 | 00 | 1019.6 | -919.603 | vwa 1
1620856 | 00 | 1019.6 | -919.603 | vwa 1
1692199 | 00 | 373.335 | 2918.2 | vwa 1
1692207 | 00 | 722.359 | 2918.2 | vwa 1
1692564 | 00 | 583.754 | 2972.2 | o 1
1692572 | 00 | 245.137 | 2972.2 | o 1; vwa 1
1694000 | 00 | 592.433 | 3220.5 | vwa 1
1694131 | 00 | 913.672 | 3220.5 | vwa 1
1694155 | 00 | 549.658 | 3203.2 | vwa 1
1694643 | 00 | 3862.84 | -888.155 | vwa 1
1694783 | 00 | 2159.93 | 3050.5 | vwa 1
1695340 | 01 | 547.645 | 3185.5 | vwa 1
1695512 | 00 | 4057.51 | -917.91 | vwa 1
1695997 | 00 | 322.151 | 3050.5 | vwa 1
1754111 | 00 | 814.5 | 3033.2 | vwa 1
1902315 | 00 | 750.911 | 3053.2 | vwa 1
1941467 | 00 | 1019.6 | -919.603 | vwa 1
1941547 | 00 | 895.988 | 3079.01 | vwa 1
1941590 | 00 | 664.988 | 3310.01 | vwa 1
1941696 | 00 | 310.988 | 3233 | vwa 1
1941880 | 00 | 326.14 | 3233 | vwa 1
1941893 | 00 | 469.62 | 3203.2 | vwa 1
1941936 | 00 | 315.268 | 3002 | vwa 1
1942183 | 00 | 744.206 | 2972.2 | vwa 1
1942207 | 00 | 583.229 | 2972.2 | vwa 1
1966141 | F | 800.093 | -1048.85 | vwa 1
1966802 | 00 | 3969.05 | -811.783 | o 2
1967137 | 00 | 5022.1 | 3377.9 | o 2
1967168 | 00 | 1372.37 | 3215.79 | o 2
1967444 | 00 | 5428.33 | 3215.79 | o 2
1968037 | F | 1419.02 | -1032.96 | vwa 1
1968498 | F | 947.797 | -1046.98 | vwa 1
1968562 | F | 1261.03 | -1052.14 | vwa 1
1969526 | 00 | 907.452 | 3050.5 | vwa 1
1969557 | 00 | 1637.39 | 3033.2 | vwa 1
1969787 | 00 | 421 | 3033.2 | vwa 1
1969823 | 00 | 400.381 | 3033.2 | vwa 1
1970135 | F | 346.433 | -1032.96 | vwa 1
1970241 | F | 1134.7 | -1048.85 | o 2
1970249 | F | 619.378 | -1048.85 | vwa 1
1970433 | F | 757.94 | -1033.47 | vwa 1
1971511 | F | 604.834 | -1050.99 | vwa 1
1971558 | F | 731.094 | -1050 | vwa 1
1971566 | F | 806.439 | -1050 | vwa 1
1971910 | F | 708.859 | -1048.85 | vwa 1
1971923 | F | 320.066 | -1048.85 | vwa 1
1971970 | F | 296.934 | -1048.85 | vwa 1
1972114 | F | 852.606 | -1050.27 | vwa 1
1972662 | F | 506.285 | -1048.85 | vwa 1
1973215 | F | 1128.51 | -1050.74 | vwa 1
1973223 | F | 203.237 | -1050.74 | vwa 1
1973286 | F | 1626.91 | -1050.27 | vwa 1
1973295 | F | 1207.44 | -1050.27 | vwa 1
1973313 | F | 7087.91 | -1050.27 | vwa 1
1973325 | F | 328.954 | -1032.97 | vwa 1
1973334 | F | 6557.69 | -1050.27 | vwa 1
1973457 | F | 614.185 | -1048.85 | vwa 1
1973504 | F | 477.017 | -1033.89 | vwa 1
1973578 | F | 84.8031 | -1033.89 | vwa 1
1973591 | F | 800.126 | -1048.85 | vwa 1
1973629 | F | 406.913 | -1050.27 | vwa 1
1973656 | F | 2262.9 | -1050.27 | vwa 1
1973674 | F | 720.764 | -1050.27 | vwa 1
1974085 | F | 272.071 | -1048.85 | vwa 7
1974095 | F | 2883.04 | -1048.85 | vwa 7
1974505 | F | 500.631 | -1034.5 | vwa 1
1974685 | F | 406.592 | -1051.8 | vwa 1
1974805 | F | 248 | -1034.5 | vwa 1
1974909 | F | 728.81 | -1051.8 | vwa 1
1974945 | F | 728.81 | -1051.8 | vwa 1
1974981 | F | 728.802 | -1051.8 | vwa 1
1975354 | F | 259.954 | -1051.8 | vwa 1
1975659 | F | 267.524 | -1051.8 | vwa 1
1975741 | 00 | 3834.37 | -889.683 | vwa 1
1975883 | 00 | 5334.68 | 3165.32 | o 3
1976129 | 00 | 1790.03 | 3003.2 | vwa 1
1976170 | 00 | 1704.38 | 3003.2 | vwa 1
1976492 | F | 580.715 | -1051.8 | vwa 1
1976514 | F | 7219.16 | -1051.8 | vwa 1
1976559 | F | 938.202 | -1051.8 | vwa 1
1976616 | F | 400.603 | -1034.5 | vwa 1
1976645 | F | 1484.82 | -1034.5 | vwa 1
1976766 | F | 941.557 | -1051.8 | vwa 1
1976839 | F | 351.477 | -1051.8 | vwa 1
1978713 | F | 811.763 | -1051.8 | vwa 1
1979566 | F | 1617.1 | -1050.47 | vwa 1
1979606 | F | 848.675 | -1050.47 | vwa 1
1979954 | F | 547.363 | -1051.8 | vwa 1
1979962 | F | 510.754 | -1051.8 | vwa 1
1979996 | F | 2196.14 | -1051.8 | vwa 1
1980187 | F | 285.238 | -1051.8 | vwa 1
1980234 | F | 4725.11 | -1051.8 | vwa 1
1980262 | F | 1011.17 | -1050.47 | vwa 1
1980902 | 00 | 1847.89 | 3074.88 | o 6
1981121 | 01 | 5023.4 | 3237 | o 6
1981178 | 00 | 3080.68 | 3074.88 | o 6
1981184 | 00 | 899.645 | 3074.88 | o 6
1981217 | 00 | 3899.37 | 3074.88 | o 6
1981415 | 00 | 3906.05 | -889.684 | o 6
1981435 | F | 512.971 | -1051.81 | vwa 1
1981473 | F | 602.521 | -1050.42 | vwa 1
1981580 | F | 514.815 | -1050.42 | vwa 1
1982010 | F | 711.761 | -1051.81 | vwa 1
1982027 | F | 671.479 | -1051.8 | vwa 1
1982072 | F | 885.053 | -1051.8 | vwa 1
1982080 | F | 188.34 | -1051.8 | vwa 1
1982139 | F | 953.242 | -1051.8 | vwa 1
1982360 | F | 1810.41 | -1051.81 | vwa 1
1982397 | F | 397.617 | -1034.5 | vwa 1
1982439 | F | 657.376 | -1051.8 | vwa 1
1982512 | F | 1144.11 | -1034.5 | vwa 1
1982580 | F | 3517.4 | -1051.8 | vwa 1
1982608 | F | 560.593 | -1051.8 | vwa 1
1984905 | 00 | 51.8148 | 1396.73 | vwa 1
1984914 | 00 | 1516.79 | 1472.9 | vwa 1
1984919 | 00 | 53.1384 | 1438.7 | vwa 1
1985454 | 00 | 873.739 | 535.761 | o 11
1985748 | F | 462.706 | -1034.49 | vwa 1
1985903 | F | 364.019 | -1052.13 | o 11
1986232 | F | 2303.45 | -1034.83 | vwa 1
1986297 | F | 336.287 | -1050.75 | vwa 1
1986326 | F | 433.121 | -1052.13 | vwa 1
1986354 | F | 428.879 | -1052.13 | vwa 1
2042818 | F | 283.927 | -1051.8 | vwa 1
2043436 | 00 | 714.683 | 3210.32 | vwa 1
2046963 | 00 | 948.325 | -886.736 | vwa 1
2046969 | F | 734.909 | -1048.85 | vwa 1
2046994 | 00 | 954.368 | -888.155 | vwa 1
2047000 | F | 734.909 | -1050.27 | vwa 1
2047028 | F | 681.379 | -1050.27 | vwa 1
2047069 | F | 781 | -1050.27 | vwa 1
2047085 | F | 1547.75 | -1050.27 | vwa 1
2047339 | F | 287.671 | -1051.81 | o 6
2047616 | F | 1303.1 | -1034.5 | vwa 1
2047624 | F | 669.526 | -1034.5 | vwa 1
2047777 | 00 | 1039.69 | -889.694 | vwa 1
2047815 | F | 551.594 | -1051.81 | vwa 1
2047831 | F | 1109.72 | -1051.81 | vwa 1
2048040 | 00 | 1003.07 | -903.075 | vwa 1
2048054 | F | 802.464 | -1032.97 | vwa 1
2048186 | F | 3628.59 | -1050.27 | vwa 1
2048254 | F | 281.594 | -1052.13 | vwa 1
2120022 | F | 462.596 | -1051.8 | vwa 1
2120053 | F | 320.267 | -1051.8 | vwa 1
2120084 | F | 308.245 | -1051.8 | vwa 1
2120247 | 00 | 1035.86 | -885.861 | vwa 1
2120282 | F | 592.228 | -1047.98 | vwa 1
2120290 | F | 348.577 | -1047.98 | vwa 1
2120899 | 00 | 1039.69 | -889.69 | vwa 1
2120922 | F | 176.732 | -1051.81 | vwa 1
2120932 | F | 575.283 | -1051.81 | vwa 1
2122100 | 00 | 1039.69 | -889.69 | vwa 1
2122108 | 00 | 1039.69 | -889.69 | vwa 1
2122116 | 00 | 1039.69 | -889.69 | vwa 1
2122164 | F | 1024.24 | -1051.81 | vwa 1
2122195 | F | 296.733 | -1051.8 | vwa 1
2122203 | F | 193.547 | -1051.81 | vwa 1
2122366 | F | 1024.21 | -1051.81 | vwa 1
2122375 | F | 11808 | -1051.8 | vwa 1
2122383 | F | 843.54 | -1051.81 | vwa 1
2122402 | F | 1024.24 | -1051.81 | vwa 1
2122411 | F | 308.755 | -1051.8 | vwa 1
2122417 | F | 182.035 | -1051.81 | vwa 1
2128128 | F | 2318.12 | -1034.5 | vwa 1
2128451 | F | 4186 | -1052.13 | vwa 1
2128594 | F | 9868.45 | -1034.84 | o 11
2128600 | F | 4666.9 | -1034.84 | o 11; vwa 1
2128707 | F | 9815.13 | -1034.83 | vwa 1
2128729 | F | 638.326 | -1034.83 | vwa 1
2288142 | 00 | 1006.59 | -906.592 | vwa 1
2292987 | 00 | 1019.6 | -919.603 | vwa 1
2293121 | F | 1278.33 | -1034.5 | vwa 1
2293604 | F | 1662.39 | -1034.5 | vwa 1
2293617 | F | 1039.47 | -1051.8 | vwa 1
2293661 | 00 | 1002.23 | -902.231 | vwa 1
2293720 | 00 | 1002.11 | -902.11 | vwa 1
2293743 | F | 2717.11 | -1032.01 | vwa 1
2293797 | F | 2223.56 | -1032.13 | vwa 1
2293808 | F | 228.753 | -1032.13 | vwa 1
2294048 | F | 258.166 | -1051.8 | vwa 1
2294190 | F | 343.653 | -1051.8 | vwa 1
2294358 | 00 | 774.603 | 3200.4 | vwa 1
2294410 | 00 | 774.603 | 3200.4 | vwa 1
2294884 | 00 | 705.073 | 3070.5 | vwa 1
2295027 | 00 | 262.066 | 3070.5 | vwa 1
2295224 | 00 | 5115 | 3185.4 | o 13
2295815 | 00 | 589.734 | 3070.5 | o 13
2295863 | 00 | 204.422 | 3053.2 | vwa 1
2295923 | 00 | 207.717 | 3070.5 | vwa 1
2296507 | 00 | 565.564 | 3070.5 | vwa 1
2296535 | 00 | 279.582 | 3070.5 | o 13
2296667 | 00 | 794.603 | 3180.4 | vwa 1
2296926 | 00 | 538.082 | 3436.92 | vwa 1
2297509 | 00 | 1004.61 | -904.61 | vwa 1
2297561 | F | 2180.6 | -1034.51 | vwa 1
2297569 | F | 2132.03 | -1034.51 | vwa 1
2297587 | F | 11779 | -1051.8 | vwa 1
2297675 | F | 420.603 | -1034.51 | vwa 1
2297871 | F | 1940.6 | -1034.51 | vwa 1
2297877 | F | 114.19 | -1034.51 | vwa 1
2297935 | 00 | 1004.11 | -904.11 | vwa 1
2298007 | F | 1213.77 | -1032.01 | vwa 1
2298013 | F | 985.631 | -1032.01 | vwa 1
2298033 | F | 333.024 | -1051.8 | vwa 1
2298202 | 00 | 1019.6 | -919.603 | vwa 1
2298320 | 00 | 547.882 | -1034.5 | vwa 1
2298395 | F | 503.155 | -1034.5 | vwa 1
2298483 | F | 293.696 | -1052.13 | vwa 1
2298557 | 00 | 1006.94 | -906.939 | vwa 1
2298578 | 00 | 1006.94 | -906.939 | vwa 1
2298605 | F | 1616.45 | -1034.84 | vwa 1
2298614 | F | 2107.71 | -1052.13 | vwa 1
2298638 | F | 1616.45 | -1034.84 | vwa 1
2298647 | F | 5449.35 | -1052.13 | vwa 1
2298800 | 00 | 1005.07 | -905.075 | vwa 1
2298867 | F | 443.426 | -1032.97 | vwa 1
2298876 | F | 1176 | -1050.27 | vwa 1
2299737 | 01 | 502.603 | 3372.4 | vwa 1
2299778 | 01 | 500.603 | 3374.4 | vwa 1
2300161 | 00 | 1090.61 | 3242.2 | vwa 1
2300248 | 00 | 1818.99 | 3259.5 | vwa 1
2300256 | 00 | 669.9 | 3259.5 | vwa 1
2300312 | 00 | 2782.59 | 3259.5 | vwa 1
2300339 | 00 | 3043.82 | 3242.2 | vwa 1
2424281 | F | 756.225 | -1032.81 | vwa 1
2424396 | F | 542.1 | -1048.85 | vwa 1
2424513 | 01 | 671.6 | 3185.53 | vwa 1
2455973 | F | 1020.07 | -920.075 | vwa 1
2470654 | 00 | 534.36 | 3440.64 | vwa 1
2470670 | 00 | 4329.98 | 3363.63 | vwa 1
2472800 | 00 | 2209.98 | 3359.91 | vwa 1
2472920 | 00 | 222.89 | 3198.84 | vwa 1
2473242 | 00 | 1134.12 | 3359.91 | vwa 1
2473323 | 00 | 957.897 | 3048.2 | vwa 1
2473478 | 00 | 228.154 | 3198.84 | vwa 1
2473548 | 00 | 2575.13 | 3048.2 | vwa 1
2473578 | 00 | 1128.18 | 3363.63 | vwa 1
2473621 | 00 | 1021.62 | -921.617 | vwa 1
2473894 | F | 267.858 | -1034.51 | vwa 1
2473903 | F | 1380.94 | -1051.81 | vwa 1
2474257 | 00 | 1017.11 | -917.11 | vwa 1
2474801 | 00 | 1015.79 | -915.79 | vwa 1
2474876 | F | 378.471 | -1030.69 | vwa 1
2474885 | F | 2155.95 | -1051.8 | vwa 1
2474988 | F | 603.287 | -1032.01 | vwa 1
2475151 | F | 195.541 | -1030.68 | vwa 1
2475188 | F | 976.509 | -1050.47 | vwa 1
2475460 | F | 758.776 | -1051.8 | vwa 1
2475844 | 01 | 2300.41 | 3259.5 | vwa 1
2475866 | 01 | 500.603 | 3374.4 | vwa 1
2475895 | 01 | 468.389 | 3272 | vwa 1
2475907 | 01 | 625.988 | 3349.01 | vwa 1
2475936 | 00 | 460.988 | 3272 | vwa 1
2475952 | 01 | 625.988 | 3349.01 | vwa 1
2476008 | 00 | 581.015 | 3272 | vwa 1
2476211 | 00 | 458.401 | 3272 | vwa 1
2476224 | 00 | 601 | 3272 | vwa 1
2476525 | 00 | 353.098 | 3242.2 | vwa 1
2476639 | 00 | 347.326 | 3259.5 | vwa 1
2476674 | 00 | 3259.33 | 3242.2 | vwa 1
2479655 | 00 | 353.383 | 3048.2 | vwa 1
2480344 | 00 | 961.874 | 3048.2 | vwa 1
2480365 | 00 | 675.941 | 3048.2 | vwa 1
2480512 | 00 | 459.383 | 3048.2 | vwa 1
2480794 | 01 | 57.3386 | 3914.69 | vwa 1
2480884 | 01 | 137.957 | 3879.01 | vwa 1
2481023 | 01 | 662.495 | 3210.32 | vwa 1
2481054 | 01 | 4400 | 3988.81 | o 12
2501964 | 01 | 1222.25 | -1129.02 | hwa 2
2502159 | F | 327.373 | -1052.13 | o 11
2502249 | F | 1527.74 | -1052.13 | o 11
2523918 | 00 | 1045 | -944.999 | vwa 1
2524002 | F | 1425.32 | -1022.01 | vwa 1
2524031 | F | 658.658 | -1051.8 | vwa 1
2524046 | F | 630.225 | -1022.01 | vwa 1
2567421 | 01 | 809.603 | 3165.4 | vwa 1
2567908 | 01 | 693.603 | 3173.4 | vwa 1
2568428 | 01 | 1177.95 | 7149.5 | o 10
2568436 | 01 | 4682 | 7149.5 | o 10
2568939 | 00 | 906.001 | 3050.5 | vwa 1
2571154 | 01 | 3896.8 | 3195.32 | o 10
2571367 | 00 | 1698.17 | 3033.2 | o 10
2571768 | 01 | 987.163 | 7311.57 | o 10
2572508 | 01 | 399.111 | 7150.36 | o 10
2572514 | 01 | 160.67 | 7150.77 | o 10
2572624 | 01 | 768.252 | 7149.53 | o 10
2572637 | 01 | 1337.4 | 7149.5 | o 10
2575187 | F | 15241.4 | -1048.85 | vwa 1
2610709 | 00 | 398.084 | 3074.88 | o 6
2674135 | F | 4926.8 | -1050.27 | vwa 1
2817701 | 00 | 1423.77 | -890.012 | o 11
2821141 | 01 | 6198.27 | -1129.02 | hwa 2
2821198 | 01 | 7164.83 | -1129.02 | hwa 2
2821232 | 01 | 6949.82 | -1129.02 | hwa 2
2821268 | 01 | 6949.82 | -1129.02 | hwa 2
2821304 | 01 | 6949.82 | -1129.02 | hwa 2
2825688 | 01 | 2237.88 | -988.31 | hwa 2
2825787 | 01 | 6589 | -988.31 | hwa 2
2825941 | 01 | 6809.77 | -988.31 | hwa 2
2826136 | 01 | 8574 | -988.31 | hwa 2
2826254 | 01 | 7229 | -988.31 | hwa 2
2826349 | 01 | 7554 | -988.31 | hwa 2
2853061 | 00 | 2310.36 | 3038 | vwa 9
2853080 | 00 | 2333.39 | 3038 | vwa 9
2853116 | 00 | 1650.39 | 3038 | vwa 9
2853239 | 00 | 3713.15 | -704.8 | vwa 9
2853463 | 00 | 3101.24 | 3038 | vwa 1
2853471 | 00 | 1807.8 | 3038 | vwa 1
2853550 | 00 | 896.3 | 3038 | vwa 1
2853649 | 00 | 434.186 | 3003.2 | o 3
2854029 | 00 | 2070.77 | 3038 | vwa 9
2854085 | 00 | 4843.64 | 3038 | vwa 9
2854097 | 00 | 328.712 | 3038 | vwa 9
2854382 | 00 | 148.647 | 3038 | vwa 9
2854940 | 00 | 26.1 | 3077 | vwa 1
2855206 | 00 | 26.125 | 3077 | vwa 9
2855268 | 00 | 26.125 | 3077 | vwa 9
2855304 | 00 | 26.125 | 3077 | vwa 9
2855344 | 00 | 958.617 | 3038 | vwa 9
2882657 | F | 6274.74 | -1053.18 | vwa 1
2885458 | F | 4287.36 | -988.31 | hwa 2
2885727 | F | 4178.38 | -988.312 | hwa 2
2885948 | F | 6949.01 | -988.312 | hwa 2
2886017 | F | 6949 | -988.312 | hwa 2
2886091 | F | 6973.5 | -988.312 | hwa 2
2886150 | F | 420 | -988.312 | hwa 2
2886503 | F | 16089.7 | -1129.02 | hwa 2
2886743 | F | 3703.68 | -1129.02 | hwa 2
2886765 | F | 5788.65 | -1129.02 | hwa 2
2891410 | F | 151.1 | -1053.18 | vwa 1
2892745 | F | 18.1591 | -1060.68 | vwa 1
2892774 | F | 6108.98 | -1060.68 | vwa 1
2892798 | F | 35218.5 | -1060.68 | vwa 1
2892924 | F | 151.1 | -1051.8 | vwa 1
2892926 | F | 18.1591 | -1059.3 | vwa 1
2892950 | F | 151.1 | -1053.18 | vwa 1
2892952 | F | 18.1591 | -1060.68 | vwa 1
2892976 | F | 151.1 | -1053.18 | vwa 1
2892978 | F | 18.1591 | -1060.68 | vwa 1
2893002 | F | 151.1 | -1053.18 | vwa 1
2893004 | F | 18.1591 | -1060.68 | vwa 1
2893324 | F | 6209.84 | -1060.68 | vwa 1
2893338 | F | 3885.81 | -1062.06 | vwa 1
2893352 | F | 7532.88 | -1060.68 | vwa 1
2893364 | F | 1146.85 | -1062.06 | vwa 1
2904260 | F | 49.1652 | -1129.02 | hwa 2
2904261 | F | 120.995 | -1079.18 | hwa 2
2904265 | F | 10780 | -1129.02 | hwa 2
2904291 | F | 24267 | -988.31 | hwa 2
2904370 | F | 365.986 | -1057.94 | vwa 1
2904564 | F | 97.8843 | -1050.23 | vwa 1
2904885 | F | 12200.4 | -1060.68 | vwa 1
2905017 | F | 23070.7 | -1050.42 | vwa 1
2908161 | 02 | 40.2948 | 9591.05 | vwa 1
2908820 | 02 | 45.6007 | 9623 | vwa 1
2909033 | 02 | 79.1208 | 9563.6 | vwa 1
2909041 | 02 | 43.6466 | 9623 | vwa 1
2909057 | 02 | 43.0584 | 9589.1 | vwa 1
2909065 | 02 | 43.6466 | 9623 | vwa 1
2909087 | 02 | 1190.06 | 9518.25 | vwa 1
2909161 | 02 | 1570 | 9518.25 | vwa 1
2913273 | 00 | 1036.38 | 3033.2 | vwa 1
2913291 | 00 | 1102.57 | 3033.2 | vwa 1
2913476 | 00 | 2299.39 | 3050.5 | vwa 1
2913484 | 00 | 764.136 | 3050.5 | vwa 1
2913542 | 00 | 858.432 | 3033.2 | vwa 1
2913826 | 00 | 2467.73 | 3033.2 | vwa 1
2913914 | 00 | 1671.87 | 3033.2 | vwa 1
2914581 | 00 | 6.29437 | 155.784 | vwa 1
2914589 | 00 | 82.5887 | 120.106 | vwa 1
2916635 | 01 | 116.561 | 3993 | vwa 1
2916764 | 01 | 80.4988 | 3993 | vwa 1
2916775 | 01 | 80.4988 | 3993 | vwa 1
2916829 | 01 | 3310.06 | 3993 | vwa 1
2916837 | 01 | 818 | 3993 | vwa 1
2916879 | 01 | 1325.32 | 3993 | vwa 1
2916887 | 01 | 1001.72 | 3993 | vwa 1
2916956 | 02 | 3543.99 | 9518.25 | vwa 1
2917158 | 02 | 1105.35 | 9518.25 | vwa 1
2917523 | 02 | 5379.17 | 4106.07 | vwa 1
2917526 | 01 | 1678.66 | 3993 | vwa 1
2917704 | F | 400 | -1129.02 | hwa 2
2918333 | F | 3130.4 | -1130.4 | hwa 2
2919023 | 00 | 6.29437 | 155.784 | vwa 4
2919025 | 00 | 87.0395 | 124.731 | vwa 1

# IfcFlowSegment: Rectangular Duct:Luka rechthoekig - verzinkt staal (T-stuk) (192)
Type - PredefinedType: RIGIDSEGMENT
Type - Pset_ElementShading - Roughness: 0.09144 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Ducts
Classification: 3A(57.55.21) (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Luka rechthoekig - verzinkt staal (T-stuk); sets with these values: 2
Pset_DuctSegmentTypeCommon - sets with these values: 3
Name (Rectangular Duct:Luka rechthoekig - verzinkt staal (T-stuk):...) | In | Length (mm) | Group
1105265 | 01 | 5.10333 | mvr 5
1520252 | 01 | 24.5616 | mvaz 1
1544966 | 01 | 30.7624 | mvt lbk1
1642684 | 01 | 256.848 | mvt lbk1
1649684 | 01 | 2797.5 | mvr 5
1649693 | 01 | 7119 | mvr 5
1649877 | 01 | 4000.54 | mvr 5
1716379 | 01 | 630 | mvaz 1
1744356 | 00 | 10682.9 | mvr 5
1787643 | 01 | 24 | mvaf 5
1788984 | 01 | 7.52766 | mvaz 1
1790036 | 01 | 3.56162 | mvaf 5
1819717 | 00 | 126.381 | mvr 5
1820783 | 01 | 25 | mvr 5
1821431 | 01 | 257.503 | mvr 5
1821467 | 01 | 1967.5 | mvr 5
1821891 | 01 | 941.005 | mvr 5
1827103 | 01 | 2669.8 | mvt lbk1
1827110 | 01 | 427.212 | mvt lbk1
1827386 | 01 | 105 | mvt lbk1
1829000 | 00 | 1812.41 | mvr 5
1864741 | 00 | 13.2482 | mvr 5
1866787 | 00 | 15.0442 | mvr 5
1868775 | 00 | 29.0418 | mvr 5
1869066 | 00 | 10.4415 | mvr 5
1875613 | 00 | 70 | mvr 5
1875955 | 00 | 241.961 | mvr 5
1876037 | 00 | 476.364 | mvr 5
1876259 | 00 | 475.662 | mvr 5
1876269 | 00 | 545.544 | mvr 5
1927305 | 00 | 3193.5 | mvt lbk1
1928424 | 00 | 1216.15 | mvt lbk1
1930883 | 00 | 2735 | mvt lbk1
1932836 | 00 | 2395.1 | mvt lbk1
1932872 | 00 | 392.423 | mvt lbk1
1950558 | 01 | 935 | mvt lbk1
1950574 | 01 | 2082.5 | mvt lbk1
1950633 | 01 | 1017.51 | mvt lbk1
1951738 | 00 | 10 | mvt lbk1
1951881 | 00 | 1985 | mvt lbk1
1951888 | 00 | 2312.54 | mvt lbk1
1955441 | 00 | 3.75 | mvr 5
1959482 | 00 | 565.525 | mvr 5
1959694 | 00 | 5411.01 | mvr 5
1959778 | 00 | 91.5574 | mvr 5
1986682 | 01 | 237.563 | mvr 5
2004607 | 01 | 2251.84 | mvt lbk1
2005508 | 01 | 7255.33 | mvt lbk1
2011344 | 01 | 82.1746 | mvt lbk1
2011477 | 01 | 560.279 | mvt lbk1
2013955 | 01 | 4.3886 | mvt lbk1
2014065 | 01 | 2108.13 | mvt lbk1
2014382 | 01 | 1126.87 | mvt lbk1
2015927 | 01 | 3355 | mvt lbk1
2017057 | 01 | 1567.05 | mvt lbk1
2028622 | 01 | 1675 | mvr 5
2029256 | 01 | 2.8125 | mvr 5
2029291 | 01 | 2.8125 | mvr 5
2029859 | 01 | 141.01 | mvr 5
2030027 | 01 | 240.709 | mvr 5
2030155 | 01 | 451.449 | mvr 5
2030162 | 01 | 3.75 | mvr 5
2030812 | 01 | 3.75 | mvr 5
2030827 | 01 | 3.75 | mvr 5
2031126 | 01 | 2520 | mvr 5
2079880 | 00 | 155.666 | mvr 5
2082610 | 00 | 58.5786 | mvr 5
2083138 | 00 | 1333.59 | mvr 5
2083147 | 00 | 1814.21 | mvr 5
2083782 | 00 | 597.5 | mvr 5
2159322 | 00 | 110 | mvr 5
2180824 | 01 | 1196.36 | mvr 5
2191003 | 01 | 339.389 | mvt lbk1
2197818 | 01 | 80.1999 | mvt lbk1
2224994 | 00 | 242.585 | mvr 5
2226139 | 00 | 3844.2 | mvr 5
2227177 | 00 | 3.39746 | mvt lbk1
2227187 | 00 | 2424.53 | mvt lbk1
2227496 | 00 | 1604.96 | mvt lbk1
2228383 | 00 | 110.02 | mvt lbk1
2228403 | 00 | 8.02495 | mvt lbk1
2240639 | 01 | 1831.99 | mvr 5
2240932 | 01 | 4.51905 | mvr 5
2240952 | 01 | 52.8203 | mvr 5
2241358 | 01 | 3890 | mvr 5
2241408 | 01 | 3.10889 | mvr 5
2241417 | 01 | 54.1725 | mvr 5
2303116 | 00 | 153.788 | mvr 5
2303245 | 00 | 8864.01 | mvr 5
2307427 | 00 | 5 | mvr 5
2307994 | 00 | 81.3112 | mvr 5
2308083 | 00 | 588.489 | mvr 5
2309583 | 00 | 3278.5 | mvr 5
2309590 | 00 | 227 | mvr 5
2327845 | 00 | 2728.17 | mvr 5
2337378 | 00 | 240 | mvr 5
2420082 | 01 | 1666.6 | mvr 5
2420607 | 01 | 3.6039 | mvr 5
2420915 | 01 | 729.289 | mvr 5
2421037 | 01 | 1894.98 | mvr 5
2425778 | 00 | 1794.49 | mvr 5
2427010 | 01 | 114.983 | mvt lbk1
2427020 | 01 | 244.384 | mvt lbk1
2427172 | 01 | 1044.7 | mvt lbk1
2427178 | 01 | 748 | mvt lbk1
2427510 | 01 | 295.647 | mvt lbk1
2428052 | 01 | 574.995 | mvt lbk1
2428153 | 01 | 4.3835 | mvt lbk1
2428611 | 01 | 15.6466 | mvt lbk1
2429881 | 01 | 3512.11 | mvt 2
2430873 | 00 | 23.3975 | mvr 5
2433360 | 00 | 184.521 | mvr 5
2435119 | 01 | 562.5 | mvt 2
2435120 | 01 | 2287 | mvt 2
2435126 | 01 | 1244.98 | mvt 2
2437055 | 01 | 3.89746 | mvt 2
2439220 | 01 | 573.097 | mvt 2
2441597 | 01 | 5.02802 | mvr 5
2442121 | 01 | 10 | mvr 5
2443897 | 01 | 1061.76 | mvr 5
2444104 | 01 | 121.314 | mvr 5
2447680 | 01 | 5 | mvt 1
2448707 | 01 | 5 | mvt 6
2450638 | 00 | 696.095 | mvr 5
2451086 | 00 | 411.307 | mvr 5
2484456 | 01 | 198.699 | mvt 2
2488833 | 01 | 4.99888 | mvt 2
2489924 | 01 | 3180.8 | mvt 2
2491289 | 01 | 266.311 | mvr 5
2492779 | 01 | 4.99888 | mvt 2
2495886 | 01 | 12.9487 | mvr 5
2496106 | 01 | 312.628 | mvr 5
2496880 | 01 | 1256.41 | mvt 2
2498518 | 01 | 552.82 | mvt 2
2531448 | 01 | 30 | mvr 5
2586725 | 00 | 71.1233 | mvr 5
2587870 | 00 | 262.585 | mvr 5
2588778 | 00 | 321.123 | mvr 5
2588975 | 00 | 6599 | mvr 5
2592041 | 00 | 1735.19 | mvr 5
2592807 | 00 | 2390 | mvr 5
2593129 | 00 | 16251.2 | mvr 5
2594176 | 00 | 360.057 | mvt lbk1
2596777 | 01 | 775 | mvt 2
2597440 | 01 | 105 | mvr 5
2598047 | 01 | 11450.8 | mvt lbk1
2598592 | 01 | 7567.5 | mvt lbk1
2599364 | 01 | 10319.5 | mvr 5
2599800 | 01 | 126.366 | mvr 5
2600255 | 01 | 50.9183 | mvt lbk1
2600304 | 01 | 421.837 | mvt lbk1
2601096 | 01 | 178.377 | mvt lbk1
2601148 | 01 | 178.377 | mvt lbk1
2602207 | 01 | 10.0481 | mvr 5
2603100 | 01 | 200 | mvt lbk1
2603377 | 01 | 495 | mvr 5
2626874 | 01 | 20 | mvr 5
2626881 | 01 | 5.29873 | mvr 5
2626951 | 01 | 1156.7 | mvr 5
2627550 | 01 | 426.221 | mvr 5
2627956 | 01 | 12924.9 | mvr 5
2628398 | 01 | 136 | mvr 5
2628495 | 01 | 125.091 | mvr 5
2628677 | 01 | 1024.97 | mvr 5
2628725 | 01 | 50 | mvr 5
2629090 | 01 | 85.1649 | mvr 5
2677567 | 01 | 288.164 | mvr 5
2696625 | 01 | 1586.6 | mvr 5
2700032 | 02 | 740.439 | mvaf 6
2700869 | 02 | 51.1 | mvaf 6
2701077 | 02 | 20 | mvaz 6
2701281 | 02 | 292.195 | mvaz 6
2701288 | 02 | 9098.89 | mvaz 6
2702299 | 02 | 27.5 | mvaz 6
2703105 | 02 | 306.5 | mvt 2
2703160 | 01 | 242.195 | mvt 2
2705678 | 02 | 6.5 | mvt 2
2705802 | 02 | 2867 | mvr 5
2705809 | 02 | 242.195 | mvr 5
2706753 | 01 | 1307.5 | mvt lbk1
2707414 | 01 | 100 | mvaz 2
2707450 | 01 | 201 | mvaz 3
2707561 | 01 | 201 | mvaz 5
2707930 | 02 | 497.04 | mvaz 6
2708004 | 02 | 9.87174 | mvaz 6
2720412 | 02 | 228.5 | mvaf 1
2722290 | 02 | 316.915 | mvaf 6
2748067 | 00 | 15 | mvt lbk1
2766399 | 01 | 6196.77 | mvr 5
2768363 | 01 | 459.69 | mvr 5
2920764 | 01 | 110.2 | mvt lbk1
2921065 | 01 | 10.9578 | mvt lbk1

# IfcFlowSegment: Rectangular Duct:Luka rechthoekig - verzinkt staal (zadel) (45)
Type - PredefinedType: RIGIDSEGMENT
Type - Pset_ElementShading - Roughness: 0.09144 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Ducts
Classification: 3A(57.55.21) (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Luka rechthoekig - verzinkt staal (zadel); sets with these values: 2
Pset_DuctSegmentTypeCommon - sets with these values: 3
Name (Rectangular Duct:Luka rechthoekig - verzinkt staal (zadel):...) | In | Length (mm) | Group
1741561 | 00 | 119.915 | mvt lbk1
1747448 | 00 | 770.873 | mvt lbk1
1747478 | 00 | 127.628 | mvt lbk1
1749053 | 00 | 736 | mvr 5
1749062 | 00 | 2207 | mvr 5
1790190 | 02 | 2506.31 | mvaf 5
1830022 | 00 | 798.978 | mvt lbk1
1830358 | 01 | 2927.5 | mvt lbk1
1830369 | 01 | 6518.82 | mvt lbk1
1866183 | 00 | 62.3565 | mvr 5
1866313 | 00 | 680.6 | mvr 5
1866322 | 00 | 1661.51 | mvr 5
1866328 | 00 | 79.4 | mvr 5
1867725 | 00 | 12647.2 | mvt lbk1
1868008 | 00 | 527.5 | mvt lbk1
1959597 | 00 | 643.958 | mvr 5
2079502 | 00 | 10029 | mvr 5
2082891 | 00 | 133.189 | mvt lbk1
2083598 | 00 | 90 | mvt lbk1
2083737 | 00 | 88.5509 | mvt lbk1
2109738 | 00 | 2884.31 | mvt lbk1
2111774 | 00 | 514.977 | mvt lbk1
2113087 | 00 | 121.127 | mvt lbk1
2113094 | 00 | 80 | mvt lbk1
2155561 | 00 | 1330.23 | mvt lbk1
2155649 | 00 | 161.162 | mvt lbk1
2161889 | 00 | 3749.3 | mvt lbk1
2216196 | 00 | 5983.49 | mvt lbk1
2226211 | 00 | 12.447 | mvr 5
2423812 | 00 | 208.704 | mvt lbk1
2424851 | 00 | 3230.69 | mvt lbk1
2424999 | 00 | 187.5 | mvt lbk1
2425210 | 00 | 2883.8 | mvt lbk1
2429165 | 00 | 8.55843 | mvt lbk1
2449334 | 01 | 3.39935 | mvt 2
2449491 | 01 | 769.899 | mvt 2
2531227 | 01 | 268.671 | mvt lbk1
2589220 | 00 | 13.7511 | mvt lbk1
2599134 | 01 | 1249.59 | mvt lbk1
2600544 | 01 | 899.143 | mvr 5
2601663 | 01 | 247.618 | mvr 5
2601677 | 01 | 439.821 | mvr 5
2624423 | 01 | 34.1343 | mvr 5
2629315 | 01 | 89.4657 | mvr 5
2707676 | 02 | 1625.53 | mvaz 1

# IfcFlowSegment: Rectangular Duct:NLRS_57_DU_verzinkt staal (T-stuk), Rectangular Duct:NLRS_57_DU_verzinkt staal (T-stuk):2564613
In: 01
Type - PredefinedType: RIGIDSEGMENT
Type - Pset_ElementShading - Roughness: 0.09144 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Ducts
Classification: 57.5 (Uniformat); Group: mvaf 3
Pset_DistributionFlowElementCommon - Reference: NLRS_57_DU_verzinkt staal (T-stuk); sets with these values: 2
Pset_DuctSegmentTypeCommon - Length: 3393.4 mm; sets with these values: 3

# IfcFlowSegment: Rectangular Duct:NLRS_57_DU_verzinkt staal (zadel) (6)
In: 01
Type - PredefinedType: RIGIDSEGMENT
Type - Pset_ElementShading - Roughness: 0.09144 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Ducts
Classification: 57.5 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: NLRS_57_DU_verzinkt staal (zadel); sets with these values: 2
Pset_DuctSegmentTypeCommon - sets with these values: 3
Name (Rectangular Duct:NLRS_57_DU_verzinkt staal (zadel):...) | Length (mm) | Group
2483268 | 395 | mvt 3
2484183 | 395 | mvt 8
2484458 | 395 | mvt 9
2484460 | 395 | mvt 7
2484867 | 355 | mvr 3
2485320 | 382 | mvr 6

# IfcFlowSegment: Round Duct:Luka rond - roestvast staal (T-stuk) (2)
In: 00
Type - PredefinedType: RIGIDSEGMENT
Type - Pset_ElementShading - Roughness: 0.09144 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Ducts
Classification: 3A(57.55.31) (Uniformat); Group: mvt lbk1
Pset_DistributionFlowElementCommon - Reference: Luka rond - roestvast staal (T-stuk); sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: Round
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Luka rond - roestvast staal (T-stuk):...) | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm)
2084052 | 342.378
2112398 | 100.597

# IfcFlowSegment: Round Duct:Luka rond - verzinkt staal ( zadel ● - █ ) (201)
Type - PredefinedType: RIGIDSEGMENT
Type - Pset_ElementShading - Roughness: 0.09144 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Ducts
Classification: 3A(57.55.21) (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Luka rond - verzinkt staal ( zadel ● - █ ); sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: Round
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Luka rond - verzinkt staal ( zadel ● - █ ):...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
1666489 | 00 | 53.1662 | mvt lbk1
1681655 | 01 | 214.477 | mvt lbk1
1761580 | 00 | 121.529 | mvt lbk1
1761775 | 00 | 177.859 | mvt lbk1
1761798 | 00 | 145.006 | mvt lbk1
1761861 | 00 | 121.529 | mvt lbk1
1761865 | 00 | 177.859 | mvt lbk1
1800492 | 01 | 1041.75 | mvr 5
1800495 | 01 | 189.085 | mvr 5
1859681 | 00 | 185 | mvr 5
1914590 | 00 | 197.215 | mvt lbk1
1928854 | 00 | 1455.54 | mvt lbk1
1931162 | 00 | 1010.45 | mvt lbk1
1932049 | 00 | 779.223 | mvt lbk1
1932079 | 00 | 652.5 | mvt lbk1
1933267 | 00 | 250.543 | mvt lbk1
1933286 | 00 | 1010.45 | mvt lbk1
1933319 | 00 | 250.543 | mvt lbk1
1956977 | 00 | 230.948 | mvr 5
1992661 | 01 | 182.367 | mvr 5
1992671 | 01 | 207.539 | mvr 5
1998264 | 01 | 807.52 | mvr 5
1999825 | 01 | 250 | mvt lbk1
1999843 | 01 | 250 | mvt lbk1
2000059 | 01 | 63.8367 | mvt lbk1
2002352 | 01 | 84.2307 | mvt lbk1
2015266 | 01 | 1173.99 | mvt lbk1
2017534 | 01 | 834.15 | mvt lbk1
2035908 | 01 | 141.128 | mvr 5
2036141 | 01 | 100.225 | mvr 5
2036177 | 01 | 137.5 | mvr 5
2036396 | 01 | 126.929 | mvr 5
2036460 | 01 | 99.7171 | mvr 5
2036559 | 01 | 1107.38 | mvr 5
2057652 | 00 | 162.731 | mvr 5
2061542 | 00 | 146.938 | mvr 5
2061877 | 00 | 1085 | mvr 5
2062748 | 00 | 167.466 | mvr 5
2062749 | 00 | 417.771 | mvr 5
2063109 | 00 | 50 | mvt lbk1
2063207 | 00 | 50 | mvt lbk1
2063250 | 00 | 933.924 | mvt lbk1
2063300 | 00 | 933.924 | mvt lbk1
2065819 | 00 | 149.929 | mvt lbk1
2066041 | 00 | 2781.17 | mvt lbk1
2066735 | 00 | 884.043 | mvt lbk1
2066902 | 00 | 149.929 | mvt lbk1
2066903 | 00 | 278.069 | mvt lbk1
2066993 | 00 | 227.477 | mvt lbk1
2067030 | 00 | 2781.17 | mvt lbk1
2067031 | 00 | 429.996 | mvt lbk1
2067191 | 00 | 278.069 | mvt lbk1
2067402 | 00 | 884.043 | mvt lbk1
2067404 | 00 | 227.477 | mvt lbk1
2067406 | 00 | 429.996 | mvt lbk1
2068797 | 00 | 900.404 | mvt lbk1
2068805 | 00 | 460.496 | mvt lbk1
2069195 | 00 | 166.364 | mvt lbk1
2069336 | 00 | 1586.64 | mvt lbk1
2083934 | 00 | 118.65 | mvt lbk1
2084284 | 00 | 435 | mvt lbk1
2084344 | 00 | 435 | mvt lbk1
2111710 | 00 | 118.65 | mvt lbk1
2127003 | 00 | 56.5375 | mvt lbk1
2155205 | 00 | 121.529 | mvt lbk1
2155209 | 00 | 177.859 | mvt lbk1
2158136 | 00 | 131.825 | mvt lbk1
2163786 | 01 | 191.464 | mvr 5
2163855 | 01 | 182.367 | mvr 5
2163857 | 01 | 207.539 | mvr 5
2163869 | 01 | 225.214 | mvr 5
2180473 | 01 | 50.7095 | mvr 5
2180575 | 01 | 16.9595 | mvr 5
2182656 | 01 | 10.8657 | mvr 5
2183010 | 01 | 537.223 | mvr 5
2183593 | 01 | 592.443 | mvr 5
2184109 | 01 | 57.5394 | mvr 5
2184181 | 01 | 75 | mvr 5
2190151 | 01 | 362.659 | mvr 5
2190252 | 01 | 398.142 | mvr 5
2190592 | 01 | 967.417 | mvt lbk1
2191263 | 01 | 101.269 | mvt lbk1
2197880 | 01 | 834.15 | mvt lbk1
2201219 | 01 | 326.545 | mvt lbk1
2202671 | 01 | 45 | mvr 5
2202809 | 01 | 112.086 | mvt lbk1
2202973 | 01 | 127.086 | mvt lbk1
2203355 | 01 | 686.866 | mvr 5
2204257 | 01 | 20.5267 | mvr 5
2204346 | 01 | 1822.51 | mvr 5
2204408 | 01 | 1954.48 | mvr 5
2205404 | 01 | 63.8678 | mvt lbk1
2205572 | 01 | 1643.2 | mvt lbk1
2215814 | 00 | 94.1096 | mvt lbk1
2229347 | 00 | 197.516 | mvt lbk1
2229940 | 00 | 229.892 | mvr 5
2230297 | 00 | 109.133 | mvr 5
2230454 | 00 | 109.133 | mvr 5
2230846 | 00 | 62.2337 | mvr 5
2230854 | 00 | 85 | mvr 5
2231579 | 00 | 53.1662 | mvr 5
2233459 | 00 | 46.0792 | mvr 5
2233511 | 00 | 486.436 | mvr 5
2234095 | 00 | 147.924 | mvr 5
2234105 | 00 | 208.65 | mvr 5
2308387 | 00 | 256.839 | mvr 5
2308588 | 00 | 85.6605 | mvr 5
2308721 | 00 | 143.5 | mvr 5
2308970 | 00 | 267.5 | mvr 5
2332027 | 00 | 2361.13 | mvt lbk1
2332213 | 00 | 138.5 | mvt lbk1
2333031 | 00 | 108.564 | mvt lbk1
2333178 | 00 | 4.61941 | mvt lbk1
2333236 | 00 | 7620.25 | mvt lbk1
2333654 | 00 | 870.073 | mvt lbk1
2333697 | 00 | 779.223 | mvt lbk1
2334428 | 00 | 93.75 | mvt lbk1
2334526 | 00 | 5.625 | mvt lbk1
2436180 | 01 | 2940.57 | mvt 2
2436182 | 01 | 1345.13 | mvt 2
2436184 | 01 | 614.15 | mvt 2
2436239 | 01 | 256.727 | mvt 2
2436241 | 01 | 433.752 | mvt 2
2436245 | 01 | 78.45 | mvt 2
2436261 | 01 | 1201.25 | mvt 2
2436270 | 01 | 198 | mvt 2
2436275 | 01 | 113.05 | mvt 2
2436281 | 01 | 27.5 | mvt 2
2436307 | 01 | 109.69 | mvt 2
2436310 | 01 | 179.69 | mvt 2
2447306 | 01 | 860 | mvt 2
2471949 | 00 | 126.247 | mvt lbk1
2472019 | 00 | 133.221 | mvt lbk1
2472131 | 00 | 147.332 | mvt lbk1
2472189 | 00 | 88.2211 | mvt lbk1
2490429 | 01 | 73.8609 | mvt 2
2490564 | 01 | 3396.9 | mvt 2
2490950 | 01 | 76.6187 | mvt 2
2490990 | 01 | 1486.66 | mvt 2
2491111 | 01 | 698.586 | mvt 2
2491145 | 01 | 639.795 | mvt 2
2492806 | 01 | 17986.8 | mvt 2
2492849 | 01 | 429.685 | mvt 2
2492850 | 01 | 66.5327 | mvt 2
2492939 | 01 | 690.397 | mvt 2
2492954 | 01 | 1344.38 | mvt 2
2497893 | 01 | 325.596 | mvt 2
2498356 | 01 | 365.888 | mvt 2
2536646 | 01 | 4778 | mvaf 3
2575567 | 00 | 1394.25 | mvr 5
2575577 | 00 | 131.25 | mvr 5
2575597 | 00 | 41.25 | mvr 5
2575928 | 00 | 214.75 | mvr 5
2576269 | 00 | 38.75 | mvr 5
2576759 | 00 | 481 | mvr 5
2576766 | 00 | 407 | mvr 5
2576852 | 00 | 687 | mvr 5
2576916 | 00 | 269.025 | mvr 5
2576952 | 00 | 213.726 | mvr 5
2576962 | 00 | 827.452 | mvr 5
2576979 | 00 | 255.024 | mvr 5
2577114 | 00 | 37.2485 | mvr 5
2577283 | 00 | 87.5 | mvr 5
2577549 | 00 | 111.794 | mvr 5
2577838 | 00 | 177 | mvr 5
2578013 | 00 | 128.206 | mvr 5
2581572 | 00 | 138.73 | mvr 5
2581582 | 00 | 13 | mvr 5
2581889 | 00 | 287.203 | mvr 5
2582047 | 00 | 1361 | mvt lbk1
2582053 | 00 | 571.469 | mvt lbk1
2582064 | 00 | 157.75 | mvt lbk1
2582280 | 00 | 15 | mvt lbk1
2582447 | 00 | 304.342 | mvt lbk1
2582641 | 00 | 101.566 | mvt lbk1
2582717 | 00 | 244 | mvt lbk1
2582908 | 00 | 199.342 | mvt lbk1
2582934 | 00 | 247.781 | mvt lbk1
2583302 | 00 | 459.5 | mvr 5
2585981 | 00 | 226.261 | mvr 5
2590064 | 00 | 2243.42 | mvr 5
2590441 | 00 | 2694.97 | mvr 5
2590520 | 00 | 411.384 | mvr 5
2590627 | 00 | 797.814 | mvr 5
2594593 | 00 | 229.917 | mvt lbk1
2594601 | 00 | 292.5 | mvt lbk1
2594710 | 00 | 694.737 | mvt lbk1
2594830 | 00 | 342.677 | mvt lbk1
2598771 | 00 | 199.477 | mvt lbk1
2601535 | 01 | 135.594 | mvr 5
2602658 | 01 | 431.488 | mvr 5
2604731 | 01 | 23.1649 | mvr 5
2611040 | 00 | 379.867 | mvt lbk1
2611590 | 00 | 43 | mvt lbk1
2613091 | 00 | 71.5254 | mvr 5
2618938 | 01 | 311.192 | mvt 2
2624909 | 01 | 5646.08 | mvr 5
2626788 | 01 | 244.034 | mvr 5
2880239 | 00 | 35.1522 | mvr 5
2880263 | 00 | 261.084 | mvr 5
2880331 | 00 | 182.579 | mvr 5

# IfcFlowSegment: Round Duct:Luka rond - verzinkt staal (T-stuk) (614)
Type - PredefinedType: RIGIDSEGMENT
Type - Pset_ElementShading - Roughness: 0.09144 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Ducts
Classification: 3A(57.55.21) (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Luka rond - verzinkt staal (T-stuk); sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: Round
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Round Duct:Luka rond - verzinkt staal (T-stuk):...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
1460078 | 00 | 134.08 | mvr 5
1460147 | 00 | 100.33 | mvr 5
1466055 | 00 | 484.005 | mvr 5
1496239 | 00 | 227.1 | mvr 5
1496279 | 00 | 450.25 | mvr 5
1496439 | 00 | 431.275 | mvr 5
1496499 | 00 | 84.5952 | mvr 5
1496574 | 00 | 250.25 | mvr 5
1658686 | 00 | 762.85 | mvt lbk1
1658751 | 00 | 762.85 | mvt lbk1
1658800 | 00 | 155.55 | mvt lbk1
1660355 | 00 | 675.15 | mvt lbk1
1660365 | 00 | 675.4 | mvt lbk1
1660388 | 00 | 2815.58 | mvt lbk1
1660397 | 00 | 675.4 | mvt lbk1
1666470 | 00 | 140.4 | mvt lbk1
1674115 | 00 | 1031.1 | mvt lbk1
1674612 | 00 | 167.5 | mvt lbk1
1677514 | 01 | 745.95 | mvr 5
1677586 | 01 | 335.723 | mvr 5
1681992 | 01 | 320 | mvr 5
1682465 | 01 | 1100 | mvr 5
1682490 | 01 | 1443.36 | mvr 5
1683736 | 01 | 1123.36 | mvr 5
1689925 | 00 | 173.675 | mvt lbk1
1690270 | 00 | 657.441 | mvt lbk1
1690280 | 00 | 196.6 | mvt lbk1
1691995 | 00 | 3247.15 | mvt lbk1
1692409 | 01 | 167.626 | mvr 5
1692413 | 01 | 119.205 | mvr 5
1692417 | 01 | 394.89 | mvr 5
1692422 | 01 | 589.95 | mvr 5
1692427 | 01 | 79.2046 | mvr 5
1692434 | 01 | 387 | mvr 5
1692437 | 01 | 119.205 | mvr 5
1692447 | 01 | 119.205 | mvr 5
1692877 | 00 | 350 | mvt lbk1
1701334 | 01 | 783.835 | mvr 5
1703148 | 00 | 952.171 | mvr 5
1703449 | 00 | 763.013 | mvr 5
1706290 | 01 | 317.5 | mvr 5
1720888 | 00 | 590 | mvt lbk1
1720900 | 00 | 600.817 | mvt lbk1
1720914 | 00 | 590 | mvt lbk1
1721112 | 00 | 336.875 | mvt lbk1
1721121 | 00 | 600.817 | mvt lbk1
1722106 | 00 | 70 | mvt lbk1
1722168 | 00 | 70 | mvt lbk1
1722542 | 00 | 110 | mvt lbk1
1722560 | 00 | 110 | mvt lbk1
1726026 | 00 | 150 | mvt lbk1
1726188 | 00 | 150 | mvt lbk1
1726304 | 00 | 600.817 | mvt lbk1
1728403 | 00 | 114.941 | mvr 5
1728432 | 00 | 116.538 | mvr 5
1728522 | 00 | 179.513 | mvr 5
1760157 | 00 | 197.506 | mvt lbk1
1761378 | 00 | 600.817 | mvt lbk1
1761639 | 00 | 600.817 | mvt lbk1
1761903 | 00 | 600.817 | mvt lbk1
1762002 | 00 | 7160.54 | mvr 5
1871374 | 00 | 2048.54 | mvr 5
1871403 | 00 | 1176.97 | mvr 5
1877380 | 00 | 133.462 | mvr 5
1877394 | 00 | 358.167 | mvr 5
1877554 | 00 | 937.975 | mvr 5
1877631 | 00 | 96.7892 | mvr 5
1877684 | 00 | 745.95 | mvr 5
1877692 | 00 | 46.3142 | mvr 5
1877705 | 00 | 783.925 | mvr 5
1878061 | 00 | 169.324 | mvr 5
1878117 | 00 | 170.583 | mvr 5
1883409 | 00 | 125.543 | mvr 5
1911688 | 00 | 412.961 | mvr 5
1912198 | 00 | 98.075 | mvr 5
1912327 | 01 | 28.2631 | mvr 5
1912337 | 01 | 97.588 | mvr 5
1912413 | 01 | 218.461 | mvr 5
1912445 | 01 | 3207.87 | mvr 5
1912700 | 01 | 97.588 | mvr 5
1913982 | 00 | 211.233 | mvt lbk1
1914001 | 00 | 1928.08 | mvt lbk1
1914015 | 00 | 211.233 | mvt lbk1
1914018 | 01 | 616 | mvt lbk1
1915674 | 00 | 1464.48 | mvt lbk1
1930803 | 00 | 1613.55 | mvt lbk1
1937272 | 00 | 249.198 | mvr 5
1937880 | 00 | 103.821 | mvr 5
1937890 | 00 | 332.61 | mvr 5
1940044 | 00 | 892.744 | mvr 5
1940436 | 00 | 147.2 | mvr 5
1940474 | 00 | 1062.03 | mvr 5
1940509 | 00 | 330.05 | mvr 5
1940924 | 00 | 1120.19 | mvr 5
1947848 | 00 | 334.726 | mvr 5
1953305 | 00 | 328.043 | mvr 5
1954178 | 00 | 66.0526 | mvr 5
1954191 | 00 | 285.492 | mvr 5
1954195 | 00 | 1780.47 | mvr 5
1954857 | 00 | 254.55 | mvr 5
1954977 | 00 | 74.0019 | mvr 5
1956173 | 00 | 2880.03 | mvr 5
1956207 | 00 | 115.1 | mvr 5
1956214 | 00 | 154 | mvr 5
1956218 | 00 | 33.05 | mvr 5
1956343 | 00 | 546.675 | mvr 5
1956920 | 00 | 144.027 | mvr 5
1956935 | 00 | 794.577 | mvr 5
1956963 | 00 | 198.771 | mvr 5
1958416 | 00 | 925.668 | mvr 5
1960743 | 00 | 222.5 | mvt lbk1
1963145 | 00 | 298.011 | mvr 5
1965499 | 00 | 152.666 | mvt lbk1
1996978 | 01 | 674 | mvr 5
1997222 | 01 | 1056.5 | mvr 5
1998188 | 01 | 318.27 | mvr 5
1998205 | 01 | 272.77 | mvr 5
1998224 | 01 | 89.1311 | mvr 5
1999833 | 01 | 496.65 | mvt lbk1
1999874 | 01 | 628.075 | mvt lbk1
1999921 | 01 | 496.65 | mvt lbk1
2000421 | 01 | 579.138 | mvt lbk1
2002006 | 01 | 484.225 | mvt lbk1
2002087 | 01 | 5950.55 | mvt lbk1
2002096 | 01 | 484.225 | mvt lbk1
2002203 | 01 | 10.2183 | mvt lbk1
2002206 | 01 | 484.225 | mvt lbk1
2002344 | 01 | 2158.13 | mvt lbk1
2002527 | 01 | 60.2285 | mvt lbk1
2002530 | 01 | 484.225 | mvt lbk1
2009398 | 01 | 764.15 | mvt lbk1
2009443 | 01 | 1428.08 | mvt lbk1
2009450 | 01 | 764.15 | mvt lbk1
2009530 | 01 | 2971.25 | mvt lbk1
2009538 | 01 | 4796.35 | mvt lbk1
2013089 | 01 | 891.604 | mvt lbk1
2014167 | 01 | 484.225 | mvt lbk1
2014269 | 01 | 484.225 | mvt lbk1
2014921 | 01 | 891.467 | mvt lbk1
2015231 | 01 | 1150 | mvt lbk1
2015239 | 01 | 2798.69 | mvt lbk1
2016933 | 01 | 106.732 | mvt lbk1
2018858 | 01 | 548.025 | mvt lbk1
2018886 | 01 | 548.025 | mvt lbk1
2018948 | 01 | 42.0936 | mvt lbk1
2018954 | 01 | 91.0151 | mvt lbk1
2019110 | 01 | 1220.03 | mvt lbk1
2020782 | 01 | 145.238 | mvr 5
2020794 | 01 | 417.89 | mvr 5
2021296 | 01 | 163.664 | mvr 5
2023836 | 01 | 3017.95 | mvr 5
2026498 | 01 | 5600.61 | mvr 5
2026671 | 01 | 803.108 | mvr 5
2026750 | 01 | 4317.5 | mvr 5
2026756 | 01 | 437.5 | mvr 5
2026867 | 01 | 5116.51 | mvr 5
2027521 | 01 | 2144.87 | mvr 5
2032128 | 01 | 97 | mvr 5
2032217 | 01 | 43.705 | mvr 5
2032227 | 01 | 84.2815 | mvr 5
2032261 | 01 | 50 | mvr 5
2032390 | 01 | 255 | mvr 5
2032841 | 01 | 1350.21 | mvr 5
2033202 | 01 | 145 | mvr 5
2033247 | 01 | 65 | mvr 5
2033680 | 01 | 256.447 | mvr 5
2033734 | 01 | 55.1507 | mvr 5
2033748 | 01 | 511.115 | mvr 5
2033786 | 01 | 122.884 | mvr 5
2033797 | 01 | 287 | mvr 5
2035112 | 01 | 151.455 | mvr 5
2035246 | 01 | 75 | mvr 5
2035459 | 01 | 663.154 | mvr 5
2035629 | 01 | 2108.38 | mvr 5
2035992 | 01 | 1601.66 | mvr 5
2037407 | 01 | 126.786 | mvr 5
2037477 | 01 | 415.324 | mvr 5
2050181 | 01 | 565.05 | mvr 5
2050205 | 01 | 687 | mvr 5
2068876 | 00 | 254.596 | mvt lbk1
2068884 | 00 | 188.29 | mvt lbk1
2071295 | 00 | 111.963 | mvr 5
2073134 | 00 | 1296.67 | mvr 5
2073150 | 00 | 310.897 | mvr 5
2073162 | 00 | 167.701 | mvr 5
2073895 | 00 | 5431.5 | mvt lbk1
2073957 | 00 | 459.668 | mvt lbk1
2074455 | 00 | 155.182 | mvt lbk1
2077948 | 00 | 135.602 | mvt lbk1
2077951 | 00 | 232.761 | mvt lbk1
2077982 | 00 | 1254.88 | mvt lbk1
2077992 | 00 | 939 | mvt lbk1
2084788 | 00 | 437.703 | mvt lbk1
2126447 | 00 | 3901.15 | mvt lbk1
2126486 | 00 | 3901.15 | mvt lbk1
2127584 | 00 | 740.4 | mvt lbk1
2146580 | 00 | 58.0429 | mvr 5
2146650 | 00 | 1006.72 | mvr 5
2150097 | 00 | 170.453 | mvr 5
2150114 | 00 | 304.157 | mvr 5
2150231 | 00 | 3.91778 | mvr 5
2150398 | 00 | 305.572 | mvr 5
2150491 | 00 | 100.53 | mvr 5
2150500 | 00 | 271.312 | mvr 5
2150539 | 00 | 145.154 | mvr 5
2150720 | 00 | 77.6543 | mvr 5
2150825 | 00 | 55.2951 | mvr 5
2150979 | 00 | 41.5201 | mvr 5
2151103 | 00 | 42.75 | mvr 5
2151169 | 00 | 10 | mvr 5
2151548 | 00 | 50.8452 | mvr 5
2151651 | 00 | 234.5 | mvr 5
2151980 | 00 | 296 | mvr 5
2152060 | 00 | 74.63 | mvr 5
2155069 | 00 | 695.95 | mvr 5
2155084 | 00 | 571.9 | mvr 5
2155203 | 00 | 674.066 | mvt lbk1
2155738 | 00 | 2418.95 | mvt lbk1
2156581 | 00 | 2023.75 | mvt lbk1
2156776 | 00 | 102.505 | mvt lbk1
2156887 | 00 | 740.4 | mvt lbk1
2157436 | 00 | 213.745 | mvt lbk1
2157683 | 00 | 90.596 | mvt lbk1
2157691 | 00 | 1505.42 | mvt lbk1
2158016 | 00 | 80 | mvt lbk1
2158266 | 00 | 65.825 | mvt lbk1
2158507 | 00 | 1160.43 | mvr 5
2158513 | 00 | 1211.06 | mvr 5
2158587 | 00 | 2.72187 | mvr 5
2158961 | 00 | 2547.53 | mvr 5
2159631 | 00 | 204.458 | mvr 5
2159650 | 00 | 5858.73 | mvr 5
2160500 | 00 | 61.7419 | mvr 5
2160670 | 00 | 45 | mvr 5
2160788 | 00 | 287 | mvr 5
2160796 | 00 | 1605 | mvr 5
2161296 | 00 | 1023 | mvr 5
2184779 | 01 | 225.864 | mvr 5
2184791 | 01 | 276.05 | mvr 5
2184831 | 01 | 276.05 | mvr 5
2184931 | 01 | 8692.54 | mvr 5
2185699 | 01 | 642.661 | mvr 5
2190741 | 01 | 274.363 | mvt lbk1
2190840 | 01 | 1879.5 | mvt lbk1
2191361 | 01 | 116.238 | mvt lbk1
2191510 | 01 | 142.718 | mvt lbk1
2192043 | 01 | 327.11 | mvr 5
2192119 | 01 | 14002.7 | mvr 5
2193077 | 01 | 108.216 | mvt lbk1
2193176 | 01 | 1243.79 | mvt lbk1
2193421 | 01 | 2333.79 | mvr 5
2193534 | 01 | 108.216 | mvr 5
2193705 | 01 | 2908.16 | mvr 5
2193713 | 01 | 540.777 | mvr 5
2194043 | 01 | 155.8 | mvr 5
2194315 | 01 | 350.512 | mvr 5
2194601 | 01 | 665.974 | mvr 5
2194832 | 01 | 130 | mvt lbk1
2195007 | 01 | 285.407 | mvt lbk1
2195217 | 01 | 186.018 | mvt lbk1
2195432 | 01 | 74.9823 | mvt lbk1
2195508 | 01 | 505.607 | mvt lbk1
2197693 | 01 | 1584.09 | mvt lbk1
2198023 | 01 | 638.292 | mvt lbk1
2198355 | 01 | 893.718 | mvr 5
2198512 | 01 | 50.2568 | mvr 5
2198696 | 01 | 45 | mvr 5
2198785 | 01 | 70 | mvr 5
2199247 | 01 | 5535.51 | mvr 5
2199856 | 01 | 113.877 | mvr 5
2200503 | 01 | 127.5 | mvr 5
2200835 | 01 | 127.5 | mvr 5
2201203 | 01 | 1476.45 | mvt lbk1
2201558 | 01 | 1060 | mvt lbk1
2202141 | 01 | 607.5 | mvt lbk1
2202349 | 01 | 182.5 | mvt lbk1
2203489 | 01 | 29.3204 | mvr 5
2203503 | 01 | 49.2954 | mvr 5
2203517 | 01 | 49.2954 | mvr 5
2203531 | 01 | 49.2954 | mvr 5
2203659 | 01 | 16.7815 | mvr 5
2203781 | 01 | 770.245 | mvr 5
2203842 | 01 | 13.9007 | mvr 5
2203901 | 01 | 21.6336 | mvr 5
2203950 | 01 | 81.7224 | mvr 5
2203968 | 01 | 94.2224 | mvr 5
2203998 | 01 | 639.9 | mvr 5
2204004 | 01 | 59.8084 | mvr 5
2204029 | 01 | 25.6739 | mvr 5
2204043 | 01 | 25.6739 | mvr 5
2204080 | 01 | 9.61292 | mvr 5
2205752 | 01 | 120.538 | mvr 5
2205896 | 01 | 30.5151 | mvr 5
2206241 | 01 | 113.464 | mvr 5
2206538 | 01 | 71.2114 | mvr 5
2206712 | 01 | 914.646 | mvt lbk1
2206858 | 01 | 45 | mvr 5
2207101 | 01 | 4411.25 | mvt lbk1
2207161 | 01 | 407.339 | mvr 5
2212225 | 01 | 3960.49 | mvr 5
2212234 | 01 | 6195.96 | mvr 5
2212959 | 01 | 103.734 | mvr 5
2212973 | 01 | 17.3714 | mvr 5
2212992 | 01 | 17.3714 | mvr 5
2213061 | 01 | 907.286 | mvr 5
2213137 | 01 | 36.2339 | mvr 5
2213526 | 01 | 2329.53 | mvr 5
2214100 | 01 | 69.9839 | mvr 5
2214158 | 01 | 319.414 | mvr 5
2214361 | 01 | 702.5 | mvr 5
2214549 | 01 | 173.65 | mvr 5
2214658 | 01 | 77.5 | mvr 5
2215366 | 00 | 117.5 | mvt lbk1
2215505 | 00 | 147.61 | mvt lbk1
2216051 | 00 | 463.336 | mvt lbk1
2216053 | 00 | 320.45 | mvt lbk1
2216454 | 00 | 766.535 | mvr 5
2216682 | 00 | 130.654 | mvr 5
2216885 | 00 | 720.124 | mvr 5
2217063 | 00 | 132.97 | mvr 5
2217139 | 00 | 145.763 | mvr 5
2217189 | 00 | 81.1909 | mvr 5
2217267 | 00 | 489.891 | mvr 5
2221632 | 00 | 1255.45 | mvt lbk1
2221751 | 00 | 1868.1 | mvt lbk1
2221765 | 00 | 1255.45 | mvt lbk1
2222638 | 00 | 5765 | mvt lbk1
2222905 | 00 | 333 | mvt lbk1
2223332 | 00 | 104.329 | mvt lbk1
2225588 | 00 | 580.471 | mvr 5
2226486 | 00 | 337.498 | mvr 5
2226659 | 00 | 369.924 | mvr 5
2228830 | 00 | 145.764 | mvt lbk1
2228864 | 00 | 104.119 | mvt lbk1
2228982 | 00 | 2195.29 | mvt lbk1
2229204 | 00 | 1470.58 | mvt lbk1
2229389 | 00 | 140.4 | mvt lbk1
2229516 | 00 | 43.508 | mvt lbk1
2229645 | 00 | 76.064 | mvt lbk1
2232314 | 00 | 93.5643 | mvr 5
2234040 | 00 | 3324.42 | mvr 5
2234048 | 00 | 2348.13 | mvr 5
2304387 | 00 | 2305.6 | mvr 5
2306554 | 00 | 149.863 | mvt lbk1
2306817 | 00 | 643.161 | mvt lbk1
2310223 | 01 | 671.058 | mvt lbk1
2310233 | 01 | 2124.92 | mvt lbk1
2310684 | 01 | 252.814 | mvt lbk1
2310763 | 00 | 100.575 | mvt lbk1
2310943 | 00 | 133.49 | mvt lbk1
2310989 | 00 | 1029.31 | mvt lbk1
2311049 | 00 | 708.6 | mvt lbk1
2311834 | 00 | 2269.5 | mvt lbk1
2311913 | 00 | 149.729 | mvt lbk1
2312000 | 00 | 127.691 | mvt lbk1
2312065 | 00 | 181.932 | mvt lbk1
2313461 | 00 | 97.5 | mvr 5
