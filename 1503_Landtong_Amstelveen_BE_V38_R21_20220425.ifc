Properties of the parts of a building model (IFC2X3), part 9 of 13

# IfcDistributionPort (14877)
Name | FlowDirection | Group
2 x InPort_2916879 | SOURCEANDSINK | vwa 1
2 x OutPort_2917525 | SOURCEANDSINK | vwa 1
2 x OutPort_2917630 | SOURCEANDSINK | vwa 1
2 x InPort_2916887 | SOURCEANDSINK | vwa 1
OutPort_2917618 | SOURCEANDSINK | vwa 1
InPort_2916956 | SOURCEANDSINK | vwa 1
2 x OutPort_2917543 | SOURCEANDSINK | vwa 1
2 x InPort_2917158 | SOURCEANDSINK | vwa 1
2 x OutPort_2917551 | SOURCEANDSINK | vwa 1
2 x InPort_2917523 | SOURCEANDSINK | vwa 1
InPort_2917525 | SOURCEANDSINK | vwa 1
InPort_2917618 | SOURCEANDSINK | vwa 1
InPort_2917704 | SOURCEANDSINK | hwa 2
OutPort_2917758 | SOURCEANDSINK | hwa 2
InPort_2917758 | SOURCEANDSINK | hwa 2
OutPort_2918333 | SOURCEANDSINK | hwa 2
Port_2918333 | SOURCEANDSINK | hwa 2
2 x Port_2919023 | SOURCEANDSINK | vwa 4
InPort_2919025 | SINK | vwa 1
OutPort_2919035 | SOURCE | vwa 1
InPort_2919104 | SINK | vwa 1
OutPort_2919025 | SOURCE | vwa 1
InPort_2920475 | SINK | mvt lbk1
2 x OutPort_2920769 | SOURCE | mvt lbk1
InPort_2920780 | SINK | mvt lbk1
OutPort_2920764 | SOURCE | mvt lbk1
InPort_2920769 | SINK | mvt lbk1
OutPort_2921476 | SOURCE | mvt lbk1
InPort_2920770 | SINK | mvt lbk1
InPort_2921571 | SINK | mvt lbk1
2 x OutPort_2921014 | SOURCE | mvt lbk1
InPort_2921574 | SINK | mvt lbk1
InPort_2921015 | SINK | mvt lbk1
OutPort_2921571 | SOURCE | mvt lbk1
InPort_2921025 | SINK | mvt lbk1
OutPort_2921039 | SOURCE | mvt lbk1
InPort_2921039 | SINK | mvt lbk1
OutPort_2921068 | SOURCE | mvt lbk1
InPort_2921055 | SINK | mvt lbk1
OutPort_2921362 | SOURCE | mvt lbk1
InPort_2921068 | SINK | mvt lbk1
OutPort_2921055 | SOURCE | mvt lbk1
InPort_2921066 | SINK | mvt lbk1
OutPort_2921065 | SOURCE | mvt lbk1
InPort_2921378 | SINK | mvt lbk1
OutPort_2921066 | SOURCE | mvt lbk1
InPort_2921362 | SINK | mvt lbk1
OutPort_2921378 | SOURCE | mvt lbk1
InPort_2921476 | SINK | mvt lbk1
OutPort_2921451 | SOURCE | mvt lbk1
InPort_2922161 | SINK | mvr 1
OutPort_2922160 | SOURCE | mvr 1
InPort_2922163 | SINK | mvr 1
OutPort_2922161 | SOURCE | mvr 1
Port_2922163 | SINK | mvr 1
InPort_2922281 | SINK | mvr 5
OutPort_2922252 | SOURCE | mvr 5
InPort_2924538 | SOURCEANDSINK | bra 3
OutPort_2925298 | SOURCEANDSINK | bra 3
InPort_2924611 | SOURCEANDSINK | brr 1
2 x OutPort_2924625 | SOURCEANDSINK | brr 1
2 x InPort_2924619 | SOURCEANDSINK | brr 1
2 x OutPort_2925095 | SOURCEANDSINK | brr 1
InPort_2924627 | SOURCEANDSINK | brr 1
2 x InPort_2924674 | SOURCEANDSINK | bra 3
2 x OutPort_2925076 | SOURCEANDSINK | bra 3
InPort_2924684 | SOURCEANDSINK | bra 3
InPort_2924911 | SOURCEANDSINK | bra 3
2 x OutPort_2925036 | SOURCEANDSINK | bra 3
InPort_2924932 | SOURCEANDSINK | brr 1
2 x OutPort_2925057 | SOURCEANDSINK | brr 1
2 x InPort_2924940 | SOURCEANDSINK | brr 1
2 x OutPort_2924960 | SOURCEANDSINK | brr 1
InPort_2924948 | SOURCEANDSINK | brr 1
2 x InPort_2924990 | SOURCEANDSINK | bra 3
2 x InPort_2925190 | SOURCEANDSINK | brr 1
2 x OutPort_2925247 | SOURCEANDSINK | brr 1
InPort_2925202 | SOURCEANDSINK | brr 1
2 x InPort_2925284 | SOURCEANDSINK | bra 3
2 x OutPort_2925317 | SOURCEANDSINK | bra 3
InPort_2925298 | SOURCEANDSINK | bra 3

# IfcFlowController: NLRS_50_PA_UN_watermeter_generiek:NLRS_50_PA_UN_watermeter_generiek, NLRS_50_PA_UN_watermeter_generiek:NLRS_50_PA_UN_watermeter_generiek:2505786
In: 00
Type - Classification: 50.00 (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Pipe Accessories
Pset_DistributionFlowElementCommon - Reference: NLRS_50_PA_UN_watermeter_generiek; sets with these values: 2
Group: kw 3

# IfcFlowController: NLRS_50_PIA_UN_drieweg regelklep_gen_ISR:DN50 (2)
In: 00
Type - Classification: 3A (Uniformat); Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Accessories
Pset_DistributionFlowElementCommon - Reference: DN50; sets with these values: 2
Group: brr 1
Name (NLRS_50_PIA_UN_drieweg regelklep_gen_ISR:DN50:...)
1259673
1263947

# IfcFlowController: NLRS_50_PIA_UN_kogelafsluiter type 2_gen_ISR:std (5)
In: 00
Type - Classification: 5- (Uniformat); Material: ISR_staal
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Accessories
Material: ISR_staal, Clearance Zones
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIA_UN_kogelafsluiter type 2_gen_ISR:std:...) | Group
1265965 | brr 1
1269859 | cvr 5
1269953 | cva 6
1270009 | cva 6
1270091 | cvr 5

# IfcFlowController: NLRS_50_PIA_UN_tweeweg regelklep_gen_ISR:DN32 (16)
In: 00
Type - Classification: 5- (Uniformat); Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Accessories
Pset_DistributionFlowElementCommon - Reference: DN32; sets with these values: 2
Name (NLRS_50_PIA_UN_tweeweg regelklep_gen_ISR:DN32:...) | Group
1284061 | gkwr 1
1284155 | cvr 7 (1)
1285970 | gkwr 1
1285973 | cvr 7 (1)
1286033 | gkwr 1
1286036 | cvr 7 (1)
1286123 | gkwr 1
1286126 | cvr 7 (1)
1286382 | cva 5
1286385 | cva 5
2743719 | cva 2
2743722 | cva 2
2743756 | cva 9
2743759 | cva 9
2743795 | cva 11
2743798 | cva 11

# IfcFlowController: NLRS_50_PIA_UN_vlinderklep_gen_ISR:PN16-DIN2633 (9)
In: 00
Type - Material: ISR_staal
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Accessories
Classification: 5- (Uniformat); Material: ISR_staal, Clearance Zones
Pset_DistributionFlowElementCommon - Reference: PN16-DIN2633; sets with these values: 2
Name (NLRS_50_PIA_UN_vlinderklep_gen_ISR:PN16-DIN2633:...) | Group
1251485 | brr 1
1252645 | brr 1
1254937 | brr 1
1254956 | brr 1
1262848 | bra 3
1278851 | cvr 7 (1)
1278985 | cva 5
2737921 | cvr 3
2738250 | cva 3

# IfcFlowController: NLRS_50_PIA_UN_voorlasflens DIN nested_gen_ISR:std (18)
In: 00
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Accessories
Classification: 5- (Uniformat)
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIA_UN_voorlasflens DIN nested_gen_ISR:std:...)
1251486
1251487
1252646
1252647
1254938
1254939
1254957
1254958
1262849
1262850
1278852
1278853
1278986
1278987
2737922
2737923
2738251
2738252

# IfcFlowController: NLRS_50_PIA_UN_voorlasflens nested_gen_ISR:std (8)
In: 00
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Accessories
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIA_UN_voorlasflens nested_gen_ISR:std:...)
1246539
1246540
1246541
1246542
1246543
1246544
1246545
1246546

# IfcFlowController: NLRS_53_PIA_UN_vul- en aftapkraan_gen_ISR1:DN20 (6)
In: 00
Type - Classification: 5- (Uniformat); Material: ISR_messing
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Accessories
Pset_DistributionFlowElementCommon - Reference: DN20; sets with these values: 2
Pset_ValveTypeCommon - Size: 6096 mm
Name (NLRS_53_PIA_UN_vul- en aftapkraan_gen_ISR1:DN20:...) | Group
1275904 | gkwa 2
1275909 | cva 5
1285230 | cvr 7 (4)
1285438 | gkwr 1
1285982 | cvr 7 (1)
1285987 | gkwr 1

# IfcFlowController: NLRS_53_PIA_UN_vul- en aftapkraan_gen_ISR1:DN20 (14)
In: 00
Type - Material: ISR_messing
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Accessories
Classification: 5- (Uniformat)
Pset_DistributionFlowElementCommon - Reference: DN20; sets with these values: 2
Pset_ValveTypeCommon - Size: 6096 mm
Name (NLRS_53_PIA_UN_vul- en aftapkraan_gen_ISR1:DN20:...) | Group
1274370 | gkwr 1
1274375 | cvr 7 (1)
1286045 | cvr 7 (1)
1286050 | gkwr 1
1286135 | cvr 7 (1)
1286140 | gkwr 1
1286394 | cva 5
1286399 | cva 5
2743731 | cva 2
2743736 | cva 2
2743768 | cva 9
2743773 | cva 9
2743807 | cva 11
2743812 | cva 11

# IfcFlowController: NLRS_53_PIA_UN_vul- en aftapkraan_gen_ISR1:DN25 (3)
In: 00
Type - Classification: 5- (Uniformat); Material: ISR_messing
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Accessories
Pset_DistributionFlowElementCommon - Reference: DN25; sets with these values: 2
Pset_ValveTypeCommon - Size: 7620 mm
Name (NLRS_53_PIA_UN_vul- en aftapkraan_gen_ISR1:DN25:...) | Group
1257197 | brr 1
1259249 | brr 1
1282375 | gkwa 2

# IfcFlowFitting: 300_57_ISR_recht_dummy_flange:dummy flange (2)
Type - Classification: 3A(57) (Uniformat); Material: Glass
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: dummy flange; sets with these values: 2
Name (300_57_ISR_recht_dummy_flange:dummy flange:...) | In | Group
2083599 | 00 | mvt lbk1
2603378 | 01 | mvr 5

# IfcFlowFitting: 350_57_rechth_T-stuk_Luka:verzinkt_staal (22)
Type - Description: Rechthoekig T-stuk 90º; PredefinedType: JUNCTION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt (4)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal; sets with these values: 2
Name (350_57_rechth_T-stuk_Luka:verzinkt_staal:...) | In | Group
1706954 | 00 | mvr 5
1821466 | 01 | mvr 5
1866786 | 00 | mvr 5
1876268 | 00 | mvr 5
1926884 | 00 | mvt lbk1
1951963 | 00 | mvt lbk1
1955450 | 00 | mvr 5
2014114 | 01 | mvt lbk1
2014381 | 01 | mvt lbk1
2017056 | 01 | mvt lbk1
2018397 | 01 | mvt lbk1
2021115 | 01 | mvr 5
2083781 | 00 | mvr 5
2185820 | 01 | mvr 5
2215937 | 00 | mvt lbk1
2327898 | 00 | mvr 5
2337421 | 00 | mvr 5
2441670 | 01 | mvr 5
2531045 | 01 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2563408 | 01 | mvt lbk1
2601637 | 01 | mvr 5
2629395 | 01 | mvr 5

# IfcFlowFitting: 350_57_rechth_aftakking_Luka:verzinkt_staal (5)
Type - Description: Rechthoekig - aftakking 90º; PredefinedType: JUNCTION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt (2)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal; sets with these values: 2
Name (350_57_rechth_aftakking_Luka:verzinkt_staal:...) | In | Group
2226364 | 00 | mvr 5
2449468 | 01 | mvt 2
2531275 | 01 | mvt lbk1
2577509 | 00 | mvr 5
2629248 | 01 | mvr 5

# IfcFlowFitting: 350_57_rechth_deksel_Luka:verzinkt_staal (5)
Type - Description: Rechthoekig - deksel; PredefinedType: USERDEFINED; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal; sets with these values: 2
Name (350_57_rechth_deksel_Luka:verzinkt_staal:...) | In | Group
1931354 | 00 | mvt lbk1
2484240 | 01 | mvt 2
2484650 | 01 | mvt 2
2486471 | 01 | mvr 5
2486482 | 01 | mvr 5

# IfcFlowFitting: 350_57_rechth_verloop_rh_Luka:15º verzinkt_staal (2)
Type - Description: Rechthoekig - verloopstuk; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt (3)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: 15º verzinkt_staal; sets with these values: 2
Group: mvr 5
Name (350_57_rechth_verloop_rh_Luka:15º verzinkt_staal:...) | In
1869143 | 00
2628926 | 01

# IfcFlowFitting: 350_57_rechth_verloop_rh_Luka:30º verzinkt_staal (4)
Type - Description: Rechthoekig - verloopstuk; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: 30º verzinkt_staal; sets with these values: 2
Name (350_57_rechth_verloop_rh_Luka:30º verzinkt_staal:...) | In | Group
1866482 | 00 | mvr 5
2020037 | 01 | mvt lbk1
2488867 | 01 | mvt 2
2602254 | 01 | mvr 5

# IfcFlowFitting: 350_57_rechth_verloop_rh_Luka:30º verzinkt_staal (16)
Type - Description: Rechthoekig - verloopstuk; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt (3)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: 30º verzinkt_staal; sets with these values: 2
Name (350_57_rechth_verloop_rh_Luka:30º verzinkt_staal:...) | In | Group
1827996 | 01 | mvt lbk1
1951380 | 01 | mvt lbk1
1952088 | 00 | mvt lbk1
1952257 | 00 | mvt lbk1
2000615 | 01 | mvt lbk1
2083225 | 00 | mvr 5
2155696 | 00 | mvt lbk1
2227600 | 00 | mvt lbk1
2336676 | 00 | mvr 5
2428259 | 01 | mvt lbk1
2429273 | 00 | mvt lbk1
2430998 | 00 | mvr 5
2495965 | 01 | mvr 5
2626963 | 01 | mvr 5
2627380 | 01 | mvr 5
2682376 | 01 | mvaf 5

# IfcFlowFitting: 350_57_rechth_verloop_rh_Luka:60º verzinkt_staal, 350_57_rechth_verloop_rh_Luka:60º verzinkt_staal:2417611
In: 01
Type - Description: Rechthoekig - verloopstuk; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt (3)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: 60º verzinkt_staal; sets with these values: 2
Group: mvaz 1

# IfcFlowFitting: 350_57_rechth_verloop_rhor_Luka:30º verzinkt_staal (39)
Type - Description: Rechthoek op rond - verloopstuk; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: 30º verzinkt_staal; sets with these values: 2
Name (350_57_rechth_verloop_rhor_Luka:30º verzinkt_staal:...) | In | Group
1746030 | 00 | mvr 5
1746031 | 00 | mvr 5
1953770 | 00 | mvr 5
1953828 | 00 | mvr 5
2014170 | 01 | mvt lbk1
2014274 | 01 | mvt lbk1
2014422 | 01 | mvt lbk1
2014527 | 01 | mvt lbk1
2019065 | 01 | mvt lbk1
2019923 | 01 | mvt lbk1
2021386 | 01 | mvr 5
2021414 | 01 | mvr 5
2031031 | 01 | mvr 5
2031070 | 01 | mvr 5
2083786 | 00 | mvr 5
2112256 | 00 | mvt lbk1
2113525 | 00 | mvt lbk1
2159502 | 00 | mvr 5
2160243 | 00 | mvr 5
2197819 | 01 | mvt lbk1
2226879 | 00 | mvr 5
2228902 | 00 | mvt lbk1
2307493 | 00 | mvr 5
2321399 | 00 | mvr 5
2328208 | 00 | mvr 5
2328471 | 00 | mvr 5
2337470 | 00 | mvr 5
2337513 | 00 | mvr 5
2492853 | 01 | mvt 2
2492999 | 01 | mvt 2
2563583 | 01 | mvt lbk1
2601305 | 01 | mvr 5
2601639 | 01 | mvr 5
2626835 | 01 | mvr 5
2627017 | 01 | mvr 5
2920780 | 01 | mvt lbk1
2921066 | 01 | mvt lbk1
2922163 | 01 | mvr 1
2922281 | 01 | mvr 5

# IfcFlowFitting: 350_57_rechth_verloop_rhor_Luka:45º verzinkt_staal (3)
Type - Description: Rechthoek op rond - verloopstuk; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: 45º verzinkt_staal; sets with these values: 2
Name (350_57_rechth_verloop_rhor_Luka:45º verzinkt_staal:...) | In | Group
2216104 | 00 | mvt lbk1
2498516 | 01 | mvt 2
2618695 | 01 | mvr 5

# IfcFlowFitting: 350_57_rechth_verloopbocht_a_Luka:verzinkt_staal (126)
Type - Description: Rechthoekig - verlopende bocht; PredefinedType: BEND; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt (3)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal; sets with these values: 2
Name (350_57_rechth_verloopbocht_a_Luka:verzinkt_staal:...) | In | Group
1649691 | 01 | mvr 5
1649698 | 01 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
1741524 | 00 | mvt lbk1
1741661 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
1747491 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
1747553 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
1749067 | 00 | mvr 5
1820800 | 01 | mvr 5
1821200 | 01 | mvr 5
1821911 | 01 | mvr 5
1827120 | 01 | mvt lbk1
1827130 | 01 | mvt lbk1
1829169 | 00 | mvr 5
1832061 | 00 | mvr 5
1832257 | 00 | mvr 5
1864701 | 00 | mvr 5
1866321 | 00 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
1866327 | 00 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
1866338 | 00 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
1869142 | 00 | mvr 5
1932879 | 00 | mvt lbk1
1950579 | 01 | mvt lbk1
1950961 | 01 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
1951690 | 01 | mvt lbk1
1951705 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
1951750 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
1951895 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
1952042 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
1953827 | 00 | mvr 5
1959550 | 00 | mvr 5
1959819 | 00 | mvr 5
1959869 | 00 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2011604 | 01 | mvt lbk1
2013807 | 01 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2014526 | 01 | mvt lbk1
2019920 | 01 | mvt lbk1
2029305 | 01 | mvr 5
2030037 | 01 | mvr 5
2030047 | 01 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2030049 | 01 | mvr 5
2030167 | 01 | mvr 5
2082661 | 00 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2083157 | 00 | mvr 5
2083223 | 00 | mvr 5
2083749 | 00 | mvt lbk1
2113099 | 00 | mvt lbk1
2155698 | 00 | mvt lbk1
2155699 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2159330 | 00 | mvr 5
2227192 | 00 | mvt lbk1
2227598 | 00 | mvt lbk1
2228413 | 00 | mvt lbk1
2228574 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2302750 | 00 | mvr 5
2309435 | 00 | mvr 5
2309636 | 00 | mvr 5
2336829 | 00 | mvr 5
2417523 | 01 | mvaz 1
2420563 | 01 | mvr 5
2420924 | 01 | mvr 5
2420941 | 01 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2423905 | 00 | mvt lbk1
2425040 | 00 | mvt lbk1
2425043 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2425047 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2425239 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2425772 | 00 | mvr 5
2425896 | 00 | mvr 5
2427028 | 01 | mvt lbk1
2427257 | 01 | mvt lbk1
2427940 | 01 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2428062 | 01 | mvt lbk1
2428162 | 01 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2429153 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2429174 | 00 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2433942 | 01 | mvr 5
2433946 | 01 | mvr 5
2433954 | 01 | mvr 5
2435667 | 01 | mvt 2 | Material: 57_staal_sendzimir_verzinkt
2444802 | 01 | mvr 5
2449322 | 01 | mvt 2
2450626 | 00 | mvr 5
2451096 | 00 | mvr 5
2451114 | 00 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2451116 | 00 | mvr 5
2492340 | 01 | mvr 5
2492344 | 01 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2496163 | 01 | mvr 5
2496165 | 01 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2498525 | 01 | mvt 2
2498532 | 01 | mvt 2 | Material: 57_staal_sendzimir_verzinkt
2498534 | 01 | mvt 2
2531459 | 01 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2586656 | 00 | mvr 5
2586795 | 00 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2601111 | 01 | mvt lbk1
2601144 | 01 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2601155 | 01 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2601163 | 01 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2602338 | 01 | mvr 5
2602340 | 01 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2626891 | 01 | mvr 5
2627377 | 01 | mvr 5
2628417 | 01 | mvr 5
2628509 | 01 | mvr 5
2628730 | 01 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2639071 | 01 | mvr 5
2677755 | 01 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2682375 | 01 | mvaf 5 | Material: 57_staal_sendzimir_verzinkt
2696061 | 01 | mvt lbk1
2701128 | 02 | mvaz 6
2702434 | 02 | mvaz 6
2703169 | 02 | mvt 2
2703655 | 01 | mvt 2
2703658 | 01 | mvt 2
2705817 | 02 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2705905 | 02 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2705906 | 01 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2707237 | 01 | mvt lbk1 | Material: 57_staal_sendzimir_verzinkt
2707688 | 02 | mvaz 1
2708001 | 02 | mvaz 6
2708021 | 02 | mvaz 6
2722224 | 02 | mvaf 6
2722329 | 02 | mvaf 6
2768423 | 01 | mvr 5 | Material: 57_staal_sendzimir_verzinkt
2775568 | 00 | mvr 5

# IfcFlowFitting: 350_57_rond_T-stuk_Luka:roestvast_staal, 350_57_rond_T-stuk_Luka:roestvast_staal:2111709
In: 00
Type - Description: Rond - T-stuk, verkleinend of gelijkzijdig; PredefinedType: JUNCTION; Classification: 3A(57.55) (Uniformat); Material: 57_roestvast_staal_304(1.4301)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: roestvast_staal; sets with these values: 2
Group: mvt lbk1

# IfcFlowFitting: 350_57_rond_T-stuk_Luka:verzinkt_staal (109)
Type - Description: Rond - T-stuk, verkleinend of gelijkzijdig; PredefinedType: JUNCTION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal; sets with these values: 2
Name (350_57_rond_T-stuk_Luka:verzinkt_staal:...) | In | Group
1466029 | 00 | mvr 5
1496601 | 00 | mvr 5
1658750 | 00 | mvt lbk1
1660396 | 00 | mvt lbk1
1677585 | 01 | mvr 5
1692421 | 01 | mvr 5
1692433 | 01 | mvr 5
1721120 | 00 | mvt lbk1
1761638 | 00 | mvt lbk1
1761902 | 00 | mvt lbk1
1877393 | 00 | mvr 5
1877452 | 00 | mvr 5
1877704 | 00 | mvr 5
1877952 | 00 | mvr 5
1878047 | 00 | mvr 5
1912444 | 00 | mvr 5
1914014 | 00 | mvt lbk1
1914313 | 01 | mvt lbk1
1940601 | 00 | mvr 5
1956161 | 00 | mvr 5
1956217 | 00 | mvr 5
1958391 | 00 | mvr 5
1997221 | 01 | mvr 5
1999920 | 01 | mvt lbk1
2002095 | 01 | mvt lbk1
2009449 | 01 | mvt lbk1
2014166 | 01 | mvt lbk1
2014268 | 01 | mvt lbk1
2018885 | 01 | mvt lbk1
2019109 | 01 | mvt lbk1
2026670 | 01 | mvr 5
2032249 | 01 | mvr 5
2032764 | 01 | mvr 5
2033747 | 01 | mvr 5
2035458 | 01 | mvr 5
2035628 | 01 | mvr 5
2037476 | 01 | mvr 5
2050180 | 01 | mvr 5
2050204 | 01 | mvr 5
2065818 | 00 | mvt lbk1
2071234 | 00 | mvr 5
2071535 | 00 | mvr 5
2073161 | 00 | mvr 5
2074454 | 00 | mvt lbk1
2077991 | 00 | mvt lbk1
2126485 | 00 | mvt lbk1
2150113 | 00 | mvr 5
2150499 | 00 | mvr 5
2151650 | 00 | mvr 5
2155083 | 00 | mvr 5
2156886 | 00 | mvt lbk1
2158484 | 00 | mvr 5
2158575 | 00 | mvr 5
2158709 | 00 | mvr 5
2184830 | 01 | mvr 5
2197879 | 01 | mvt lbk1
2203997 | 01 | mvr 5
2212980 | 01 | mvr 5
2212991 | 01 | mvr 5
2213060 | 01 | mvr 5
2221764 | 00 | mvt lbk1
2229388 | 00 | mvt lbk1
2234104 | 00 | mvr 5
2310828 | 00 | mvt lbk1
2311048 | 00 | mvt lbk1
2312064 | 00 | mvt lbk1
2315380 | 00 | mvr 5
2315986 | 00 | mvr 5
2316771 | 00 | mvr 5
2318647 | 00 | mvr 5
2320128 | 00 | mvr 5
2320665 | 00 | mvr 5
2320748 | 00 | mvr 5
2321655 | 00 | mvt lbk1
2322432 | 00 | mvt lbk1
2323454 | 00 | mvt lbk1
2323482 | 00 | mvt lbk1
2323505 | 00 | mvt lbk1
2324091 | 00 | mvt lbk1
2328497 | 00 | mvr 5
2333050 | 00 | mvt lbk1
2436186 | 01 | mvt 2
2436210 | 01 | mvt 2
2436243 | 01 | mvt 2
2436266 | 01 | mvt 2
2436314 | 01 | mvt 2
2481316 | 01 | mvr 5
2481513 | 01 | mvr 5
2490428 | 01 | mvt 2
2490563 | 01 | mvt 2
2497062 | 01 | mvt 2
2560474 | 02 | mvt lbk1
2576758 | 00 | mvr 5
2576765 | 00 | mvr 5
2576904 | 00 | mvr 5
2576940 | 00 | mvr 5
2582446 | 00 | mvt lbk1
2583301 | 00 | mvr 5
2584601 | 00 | mvr 5
2584653 | 00 | mvr 5
2611024 | 00 | mvt lbk1
2611039 | 00 | mvt lbk1
2611544 | 00 | mvt lbk1
2613090 | 00 | mvr 5
2616961 | 01 | mvt 2
2725248 | 00 | mvt lbk1
2766237 | 01 | mvr 5
2920769 | 01 | mvt lbk1
2921014 | 01 | mvt lbk1

# IfcFlowFitting: 350_57_rond_bocht_Luka:gladde_bocht verzinkt_staal (259)
Type - Description: Rond - bochtstuk, radius 100 of D of 1,5xD; PredefinedType: BEND; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: gladde_bocht verzinkt_staal; sets with these values: 2
Name (350_57_rond_bocht_Luka:gladde_bocht verzinkt_staal:...) | In | Group
1682785 | 01 | mvr 5
1689940 | 00 | mvt lbk1
1691425 | 00 | mvt lbk1
1720912 | 00 | mvt lbk1
1720926 | 00 | mvt lbk1
1722122 | 00 | mvt lbk1
1722189 | 00 | mvt lbk1
1722558 | 00 | mvt lbk1
1722572 | 00 | mvt lbk1
1726208 | 00 | mvt lbk1
1761793 | 00 | mvt lbk1
1761867 | 00 | mvt lbk1
1761910 | 00 | mvt lbk1
1762016 | 00 | mvr 5
1800647 | 01 | mvr 5
1868311 | 00 | mvt lbk1
1877702 | 00 | mvr 5
1912345 | 01 | mvr 5
1912460 | 01 | mvr 5
1912765 | 01 | mvr 5
1914024 | 00 | mvt lbk1
1923077 | 01 | mvr 5
1923079 | 01 | mvr 5
1930101 | 00 | mvt lbk1
1933281 | 00 | mvt lbk1
1933300 | 00 | mvt lbk1
1933354 | 00 | mvt lbk1
1933401 | 00 | mvt lbk1
1940622 | 00 | mvr 5
1953373 | 00 | mvr 5
1954297 | 00 | mvr 5
1956084 | 00 | mvr 5
1956104 | 00 | mvr 5
1956928 | 00 | mvr 5
1956945 | 00 | mvr 5
1956971 | 00 | mvr 5
1957036 | 00 | mvr 5
1998222 | 01 | mvr 5
1999841 | 01 | mvt lbk1
1999853 | 01 | mvt lbk1
2000083 | 01 | mvt lbk1
2002315 | 01 | mvt lbk1
2009501 | 01 | mvt lbk1
2012107 | 01 | mvt lbk1
2012311 | 01 | mvt lbk1
2015245 | 01 | mvt lbk1
2015883 | 01 | mvt lbk1
2019063 | 01 | mvt lbk1
2019777 | 00 | mvt lbk1
2021412 | 01 | mvr 5
2026699 | 01 | mvr 5
2026764 | 01 | mvr 5
2031029 | 01 | mvr 5
2032225 | 01 | mvr 5
2032635 | 01 | mvr 5
2032640 | 01 | mvr 5
2033212 | 01 | mvr 5
2033259 | 01 | mvr 5
2033688 | 01 | mvr 5
2033698 | 01 | mvr 5
2035256 | 01 | mvr 5
2035362 | 01 | mvr 5
2035364 | 01 | mvr 5
2036149 | 01 | mvr 5
2036161 | 01 | mvr 5
2062606 | 00 | mvr 5
2062758 | 00 | mvr 5
2062764 | 00 | mvr 5
2063260 | 00 | mvt lbk1
2063308 | 00 | mvt lbk1
2063385 | 00 | mvt lbk1
2063387 | 00 | mvt lbk1
2066906 | 00 | mvt lbk1
2066912 | 00 | mvt lbk1
2067034 | 00 | mvt lbk1
2067042 | 00 | mvt lbk1
2067044 | 00 | mvt lbk1
2067226 | 00 | mvt lbk1
2067412 | 00 | mvt lbk1
2067545 | 00 | mvt lbk1
2067574 | 00 | mvt lbk1
2067576 | 00 | mvt lbk1
2068890 | 00 | mvt lbk1
2068926 | 00 | mvt lbk1
2068928 | 00 | mvt lbk1
2073169 | 00 | mvr 5
2078075 | 00 | mvt lbk1
2127564 | 00 | mvt lbk1
2150321 | 00 | mvr 5
2150667 | 00 | mvr 5
2155081 | 00 | mvr 5
2155122 | 00 | mvt lbk1
2155245 | 00 | mvt lbk1
2155302 | 00 | mvt lbk1
2155304 | 00 | mvt lbk1
2156894 | 00 | mvt lbk1
2157605 | 00 | mvt lbk1
2158778 | 00 | mvr 5
2159645 | 00 | mvr 5
2159664 | 00 | mvr 5
2160785 | 00 | mvr 5
2160802 | 00 | mvr 5
2163766 | 01 | mvr 5
2163781 | 01 | mvr 5
2163865 | 01 | mvr 5
2163867 | 01 | mvr 5
2184193 | 01 | mvr 5
2193731 | 01 | mvr 5
2201936 | 01 | mvt lbk1
2202097 | 01 | mvt lbk1
2202225 | 01 | mvr 5
2204022 | 01 | mvr 5
2212242 | 01 | mvr 5
2216065 | 00 | mvt lbk1
2216069 | 00 | mvt lbk1
2216171 | 00 | mvt lbk1
2222174 | 00 | mvt lbk1
2222703 | 00 | mvt lbk1
2228898 | 00 | mvt lbk1
2228994 | 00 | mvt lbk1
2229359 | 00 | mvt lbk1
2229374 | 00 | mvt lbk1
2230121 | 00 | mvr 5
2231004 | 00 | mvr 5
2233469 | 00 | mvr 5
2233640 | 00 | mvr 5
2233958 | 00 | mvr 5
2234102 | 00 | mvr 5
2306241 | 00 | mvt lbk1
2308393 | 00 | mvr 5
2310259 | 00 | mvt lbk1
2310263 | 01 | mvt lbk1
2310771 | 00 | mvt lbk1
2310964 | 00 | mvt lbk1
2311003 | 00 | mvt lbk1
2314671 | 01 | mvt lbk1
2314693 | 01 | mvt lbk1
2315388 | 00 | mvr 5
2315680 | 00 | mvr 5
2316722 | 00 | mvr 5
2317194 | 00 | mvt lbk1
2319524 | 00 | mvr 5
2320124 | 00 | mvr 5
2320140 | 00 | mvr 5
2320746 | 00 | mvr 5
2321581 | 00 | mvt lbk1
2322388 | 00 | mvt lbk1
2322430 | 00 | mvt lbk1
2323476 | 00 | mvt lbk1
2323480 | 00 | mvt lbk1
2323501 | 00 | mvt lbk1
2323503 | 00 | mvt lbk1
2323702 | 00 | mvt lbk1
2324008 | 00 | mvt lbk1
2324078 | 00 | mvt lbk1
2327191 | 00 | mvr 5
2327193 | 00 | mvr 5
2328595 | 00 | mvr 5
2328662 | 00 | mvr 5
2332025 | 00 | mvt lbk1
2332121 | 00 | mvt lbk1
2333000 | 00 | mvt lbk1
2333002 | 00 | mvt lbk1
2333039 | 00 | mvt lbk1
2333048 | 00 | mvt lbk1
2337627 | 00 | mvr 5
2337649 | 00 | mvr 5
2338449 | 00 | mvr 5
2436188 | 01 | mvt 2
2436234 | 01 | mvt 2
2436272 | 01 | mvt 2
2436288 | 01 | mvt 2
2436292 | 01 | mvt 2
2436337 | 01 | mvt 2
2436339 | 01 | mvt 2
2436361 | 01 | mvt 2
2436367 | 01 | mvt 2
2436369 | 01 | mvt 2
2436371 | 01 | mvt 2
2445266 | 01 | mvr 5
2445268 | 01 | mvr 5
2472117 | 00 | mvt lbk1
2472143 | 00 | mvt lbk1
2490572 | 01 | mvt 2
2491065 | 01 | mvt 2
2492583 | 01 | mvt 2
2492587 | 01 | mvt 2
2492855 | 01 | mvt 2
2492915 | 01 | mvt 2
2492951 | 01 | mvt 2
2492960 | 01 | mvt 2
2497625 | 01 | mvt 2
2560496 | 02 | mvt lbk1
2560548 | 02 | mvt lbk1
2563536 | 01 | mvt lbk1
2563579 | 01 | mvt lbk1
2575583 | 00 | mvr 5
2576052 | 00 | mvr 5
2576976 | 00 | mvr 5
2577035 | 00 | mvr 5
2577297 | 00 | mvr 5
2578460 | 00 | mvr 5
2581803 | 00 | mvr 5
2582061 | 00 | mvt lbk1
2582263 | 00 | mvt lbk1
2582556 | 00 | mvt lbk1
2583541 | 00 | mvr 5
2583545 | 00 | mvr 5
2584584 | 00 | mvr 5
2584586 | 00 | mvr 5
2584612 | 00 | mvr 5
2584804 | 00 | mvr 5
2590546 | 00 | mvr 5
2590550 | 00 | mvr 5
2593555 | 00 | mvt lbk1
2594259 | 00 | mvt lbk1
2594607 | 00 | mvt lbk1
2594638 | 00 | mvt lbk1
2595945 | 00 | mvr 5
2595949 | 00 | mvr 5
2595953 | 00 | mvr 5
2595957 | 00 | mvr 5
2596482 | 01 | mvr 5
2600887 | 01 | mvr 5
2602427 | 01 | mvr 5
2602430 | 01 | mvr 5
2602435 | 01 | mvr 5
2604727 | 02 | mvr 5
2604891 | 02 | mvr 5
2605720 | 01 | mvr 5
2605724 | 01 | mvr 5
2605772 | 02 | mvr 5
2606002 | 02 | mvt lbk1
2606875 | 02 | mvr 5
2611052 | 00 | mvt lbk1
2611556 | 00 | mvt lbk1
2611917 | 00 | mvt lbk1
2612027 | 00 | mvt lbk1
2612031 | 00 | mvt lbk1
2612929 | 00 | mvr 5
2613098 | 00 | mvr 5
2617050 | 01 | mvt 2
2617505 | 01 | mvt 2
2617517 | 01 | mvt 2
2618691 | 01 | mvr 5
2618999 | 01 | mvt 2
2619003 | 01 | mvt 2
2619052 | 01 | mvt 2
2619142 | 01 | mvt 2
2627005 | 01 | mvr 5
2725204 | 00 | mvt lbk1
2725209 | 00 | mvt lbk1
2725906 | 00 | mvt lbk1
2745181 | 00 | mvr 5
2745183 | 00 | mvr 5
2775508 | 00 | mvr 5
2880461 | 00 | mvr 5
2921025 | 01 | mvt lbk1
2921068 | 01 | mvt lbk1

# IfcFlowFitting: 350_57_rond_koppelstuk_tbv_hulpstukken_Luka:verzinkt_staal 1 (111)
Type - Description: Rond - koppelstuk tbv hulpstukken; PredefinedType: CONNECTOR; Classification: 3A(57.55) (Uniformat); Material: 57_roestvast_staal_304(1.4301)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal 1; sets with these values: 2
Name (350_57_rond_koppelstuk_tbv_hulpstukken_Luka:verzinkt_staal 1:...) | In
1658787 | 00
1658788 | 00
1660918 | 00
1660919 | 00
1722068 | 00
1722069 | 00
1761943 | 00
1761944 | 00
1761957 | 00
1761958 | 00
1878168 | 00
1878185 | 00
1878229 | 00
1878231 | 00
1912469 | 01
1914062 | 00
1914063 | 00
1940656 | 00
1958516 | 00
1997246 | 01
1998279 | 01
1998284 | 01
1999977 | 01
1999978 | 01
2009471 | 01
2009472 | 01
2018911 | 01
2018912 | 01
2032803 | 01
2032881 | 01
2033277 | 01
2035075 | 01
2035096 | 01
2035677 | 01
2037909 | 01
2066878 | 00
2067225 | 00
2071590 | 00
2078025 | 00
2112806 | 00
2112807 | 00
2126705 | 00
2126706 | 00
2157088 | 00
2157089 | 00
2158676 | 00
2158782 | 00
2197907 | 01
2197908 | 01
2213081 | 01
2213591 | 01
2221802 | 00
2221803 | 00
2222983 | 00
2229568 | 00
2229569 | 00
2231008 | 00
2310697 | 01
2310703 | 01
2310959 | 00
2313290 | 00
2314699 | 01
2316003 | 00
2316668 | 00
2316721 | 00
2319543 | 00
2320115 | 00
2320146 | 00
2320157 | 00
2320782 | 00
2320830 | 00
2320831 | 00
2322387 | 00
2323462 | 00
2323463 | 00
2323500 | 00
2324129 | 00
2324130 | 00
2328680 | 00
2339912 | 01
2436196 | 01
2436352 | 01
2436355 | 01
2436360 | 01
2481631 | 01
2490358 | 01
2497221 | 01
2551501 | 00
2551502 | 00
2560708 | 02
2560709 | 02
2581608 | 00
2582363 | 00
2582491 | 00
2582492 | 00
2583243 | 00
2583318 | 00
2584640 | 00
2584963 | 00
2611051 | 00
2617565 | 01
2618935 | 01
2714103 | 00
2714134 | 00
2715025 | 00
2715161 | 00
2725227 | 00
2766283 | 01
2766308 | 01
2921577 | 01
2921578 | 01

# IfcFlowFitting: 350_57_rond_platte_tuit_Luka:verzinkt_staal (44)
Type - Description: Rond - platte tuit / zadelstuk; PredefinedType: JUNCTION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal; sets with these values: 2
Name (350_57_rond_platte_tuit_Luka:verzinkt_staal:...) | In | Group
1800651 | 01 | mvr 5
1931630 | 00 | mvt lbk1
1933000 | 00 | mvt lbk1
1933399 | 00 | mvt lbk1
1957042 | 00 | mvr 5
1958895 | 00 | mvr 5
1993257 | 01 | mvr 5
2000077 | 01 | mvt lbk1
2000398 | 01 | mvt lbk1
2015887 | 01 | mvt lbk1
2036138 | 01 | mvr 5
2036367 | 01 | mvr 5
2036954 | 01 | mvr 5
2036996 | 01 | mvr 5
2037014 | 01 | mvr 5
2062756 | 00 | mvr 5
2124346 | 00 | mvt lbk1
2163863 | 01 | mvr 5
2182725 | 01 | mvr 5
2184090 | 01 | mvr 5
2184119 | 01 | mvr 5
2202074 | 01 | mvt lbk1
2205268 | 01 | mvt lbk1
2229344 | 00 | mvt lbk1
2230125 | 00 | mvr 5
2233372 | 00 | mvr 5
2309033 | 00 | mvr 5
2332119 | 00 | mvt lbk1
2423769 | 00 | mvt lbk1
2423773 | 00 | mvt lbk1
2423777 | 00 | mvt lbk1
2423781 | 00 | mvt lbk1
2423785 | 00 | mvt lbk1
2491069 | 01 | mvt 2
2565112 | 01 | mvaf 3
2577510 | 00 | mvr 5
2577512 | 00 | mvr 5
2590517 | 00 | mvr 5
2594380 | 00 | mvt lbk1
2602402 | 01 | mvr 5
2605106 | 01 | mvr 5
2611921 | 00 | mvt lbk1
2766228 | 01 | mvr 5
2880261 | 00 | mvr 5

# IfcFlowFitting: 350_57_rond_verloop_buis_Luka:verzinkt_staal (109)
Type - Description: Rond - verloopstuk tbv kanalen; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal; sets with these values: 2
Name (350_57_rond_verloop_buis_Luka:verzinkt_staal:...) | In | Group
1658783 | 00 | mvt lbk1
1658785 | 00 | mvt lbk1
1660914 | 00 | mvt lbk1
1660916 | 00 | mvt lbk1
1722064 | 00 | mvt lbk1
1722066 | 00 | mvt lbk1
1761939 | 00 | mvt lbk1
1761941 | 00 | mvt lbk1
1761953 | 00 | mvt lbk1
1761955 | 00 | mvt lbk1
1878162 | 00 | mvr 5
1878180 | 00 | mvr 5
1878221 | 00 | mvr 5
1878223 | 00 | mvr 5
1912464 | 01 | mvr 5
1914056 | 00 | mvt lbk1
1914058 | 00 | mvt lbk1
1940654 | 00 | mvr 5
1958514 | 00 | mvr 5
1997243 | 01 | mvr 5
1998277 | 01 | mvr 5
1998282 | 01 | mvr 5
1999973 | 01 | mvt lbk1
1999975 | 01 | mvt lbk1
2009467 | 01 | mvt lbk1
2009469 | 01 | mvt lbk1
2018907 | 01 | mvt lbk1
2018909 | 01 | mvt lbk1
2032796 | 01 | mvr 5
2032878 | 01 | mvr 5
2033275 | 01 | mvr 5
2035069 | 01 | mvr 5
2035088 | 01 | mvr 5
2035675 | 01 | mvr 5
2037907 | 01 | mvr 5
2066876 | 00 | mvt lbk1
2067223 | 00 | mvt lbk1
2071588 | 00 | mvr 5
2078023 | 00 | mvt lbk1
2112802 | 00 | mvt lbk1
2112804 | 00 | mvt lbk1
2126701 | 00 | mvt lbk1
2126703 | 00 | mvt lbk1
2157084 | 00 | mvt lbk1
2157086 | 00 | mvt lbk1
2158671 | 00 | mvr 5
2158780 | 00 | mvr 5
2197903 | 01 | mvt lbk1
2197905 | 01 | mvt lbk1
2213075 | 01 | mvr 5
2213589 | 01 | mvr 5
2221798 | 00 | mvt lbk1
2221800 | 00 | mvt lbk1
2222974 | 00 | mvt lbk1
2229564 | 00 | mvt lbk1
2229566 | 00 | mvt lbk1
2231006 | 00 | mvr 5
2310698 | 01 | mvt lbk1
2310957 | 00 | mvt lbk1
2313288 | 00 | mvt lbk1
2314697 | 01 | mvt lbk1
2316000 | 00 | mvr 5
2316666 | 00 | mvr 5
2316719 | 00 | mvr 5
2319541 | 00 | mvr 5
2320113 | 00 | mvr 5
2320144 | 00 | mvr 5
2320155 | 00 | mvr 5
2320780 | 00 | mvr 5
2320826 | 00 | mvr 5
2320828 | 00 | mvr 5
2322385 | 00 | mvt lbk1
2323458 | 00 | mvt lbk1
2323460 | 00 | mvt lbk1
2323498 | 00 | mvt lbk1
2324125 | 00 | mvt lbk1
2324127 | 00 | mvt lbk1
2328678 | 00 | mvr 5
2339910 | 01 | mvr 5
2436194 | 01 | mvt 2
2436350 | 01 | mvt 2
2436353 | 01 | mvt 2
2436358 | 01 | mvt 2
2481629 | 01 | mvr 5
2490353 | 01 | mvt 2
2497219 | 01 | mvt 2
2551497 | 00 | mvt lbk1
2551499 | 00 | mvt lbk1
2560704 | 02 | mvt lbk1
2560706 | 02 | mvt lbk1
2581606 | 00 | mvr 5
2582361 | 00 | mvt lbk1
2582487 | 00 | mvt lbk1
2582489 | 00 | mvt lbk1
2583241 | 00 | mvr 5
2583316 | 00 | mvr 5
2584638 | 00 | mvr 5
2584961 | 00 | mvr 5
2617560 | 01 | mvt 2
2618933 | 01 | mvt 2
2714101 | 00 | mvt lbk1
2714132 | 00 | mvt lbk1
2715023 | 00 | mvt lbk1
2715159 | 00 | mvt lbk1
2725225 | 00 | mvt lbk1
2766275 | 01 | mvr 5
2766306 | 01 | mvr 5
2921571 | 01 | mvt lbk1
2921574 | 01 | mvt lbk1

# IfcFlowFitting: 350_57_rond_verloop_buis_Luka:verzinkt_staal (2)
Type - Description: Rond - verloopstuk tbv kanalen; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: 57_staal_sendzimir_verzinkt (3)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal; sets with these values: 2
Group: mvt lbk1
Name (350_57_rond_verloop_buis_Luka:verzinkt_staal:...) | In
2310692 | 01
2611047 | 00

# IfcFlowFitting: 350_57_rond_verloop_hulpstuk_Luka:verzinkt_staal (22)
Type - Description: Rond - verloopstuk tbv hulpstukken; PredefinedType: TRANSITION; Classification: 3A(57.55) (Uniformat); Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal; sets with these values: 2
Name (350_57_rond_verloop_hulpstuk_Luka:verzinkt_staal:...) | In | Group
1658920 | 00 | mvt lbk1
1658924 | 00 | mvt lbk1
1948853 | 00 | mvr 5
1948855 | 00 | mvr 5
1956052 | 00 | mvr 5
2037496 | 01 | mvr 5
2077956 | 00 | mvt lbk1
2158834 | 00 | mvr 5
2202076 | 01 | mvt lbk1
2205234 | 01 | mvt lbk1
2213160 | 01 | mvr 5
2213164 | 01 | mvr 5
2213632 | 01 | mvr 5
2222025 | 00 | mvt lbk1
2222030 | 00 | mvt lbk1
2234321 | 00 | mvr 5
2317302 | 00 | mvt lbk1
2317315 | 00 | mvt lbk1
2323468 | 00 | mvt lbk1
2323472 | 00 | mvt lbk1
2582249 | 00 | mvt lbk1
2585083 | 00 | mvr 5

# IfcFlowFitting: NLRS_50_PA_UN_bron_enkel:standaard (25)
In: F
Type - Classification: 50.00 (Uniformat); Material: PE zwart
Type - Pset_ProductRequirements - Category: Conduit Fittings
Pset_DistributionFlowElementCommon - Reference: standaard; sets with these values: 2
Name (NLRS_50_PA_UN_bron_enkel:standaard:...)
2503906
2504189
2504210
2504412
2504521
2504542
2504848
2504927
2504934
2504941
2504948
2505286
2505293
2505300
2505341
2505348
2505355
2505362
2505426
2505433
2505440
2659556
2659704
2659877
2664347

# IfcFlowFitting: NLRS_50_PIA_UN_voorlasflens DIN tbv verdeler_gen_ISR:PN6-DIN2631 (13)
In: 00
Type - Classification: 5- (Uniformat); Material: <Unnamed>, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs
Pset_DistributionFlowElementCommon - Reference: PN6-DIN2631; sets with these values: 2
Name (NLRS_50_PIA_UN_voorlasflens DIN tbv verdeler_gen_ISR:PN6-DIN2631:...) | Group
1246636 | gkwa 2
1274360 | gkwr 1
1274424 | cvr 7 (1)
1275293 | gkwr 1
1275364 | cvr 7 (1)
1275385 | gkwr 1
1275414 | cvr 7 (1)
1275894 | gkwa 2
1275916 | cva 5
1275924 | gkwa 2
1275928 | cva 5
1275936 | gkwa 2
1275940 | cva 5

# IfcFlowFitting: NLRS_50_PIF_UN_bocht MM_Aquatherm:std (375)
Type - Material: Aquatherm green
Type - Pset_ManufacturerTypeInformation - Manufacturer: Aquatherm
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIF_UN_bocht MM_Aquatherm:std:...) | In | Group
2147888 | 00 | cva 8
2147898 | 01 | cvr 24
2147907 | 01 | cva 10
2147916 | 01 | cvr 23
2147943 | 00 | cva 20
2147955 | 00 | cva 20
2147957 | 00 | cva 20
2147973 | 00 | cvr 11
2147985 | 00 | cvr 11
2147987 | 00 | cvr 11
2147993 | 01 | cva 8
2147997 | 00 | cvr 24
2147999 | 00 | cva 10
2148001 | 00 | cvr 23
2148003 | 00 | cva 20
2148005 | 00 | cvr 11
2148019 | 00 | cvr 1
2148027 | 00 | cva 1
2148031 | 00 | cvr 1
2148289 | 00 | cvr 11
2148291 | 00 | cva 20
2259472 | 00 | cva 20
2259504 | 00 | cvr 11
2259508 | 00 | cvr 11
2259573 | 00 | cva 20
2259604 | 00 | cva 20
2259637 | 00 | cvr 11
2259911 | 00 | cva 20
2259915 | 00 | cva 20
2259926 | 00 | cva 20
2260450 | 00 | cva 20
2260501 | 00 | cvr 11
2261391 | 00 | cva 20
2261439 | 00 | cvr 11
2261505 | 00 | cvr 11
2261510 | 00 | cvr 11
2261598 | 00 | cva 20
2261608 | 00 | cva 20
2262045 | 00 | cva 20
2262056 | 00 | cva 20
2262060 | 00 | cva 20
2262066 | 00 | cvr 11
2262077 | 00 | cvr 11
2262079 | 00 | cvr 11
2262359 | 00 | cvr 11
2262389 | 00 | cva 20
2263520 | 00 | cva 20
2263540 | 00 | cvr 11
2263549 | 00 | cva 20
2263997 | 00 | cva 20
2264021 | 00 | cva 20
2264055 | 00 | cva 20
2264080 | 00 | cvr 11
2264182 | 00 | cvr 11
2264467 | 00 | cvr 11
2550256 | 00 | cva 1
2550955 | 00 | cvr 1
2551320 | 00 | cva 1
2551330 | 00 | cva 1
2551332 | 00 | cva 1
2551338 | 00 | cvr 1
2551340 | 00 | cvr 1
2551850 | 00 | cva 20
2551852 | 00 | cva 20
2554391 | 00 | cvr 11
2554960 | 00 | cvr 11
2596045 | 00 | cva 20
2596084 | 00 | cva 20
2596101 | 00 | cva 20
2596115 | 00 | cva 20
2596229 | 00 | cvr 11
2596254 | 00 | cvr 11
2596262 | 00 | cvr 11
2596266 | 00 | cvr 11
2715999 | 00 | gkwr 2
2716227 | 00 | gkwr 2
2716235 | 00 | gkwr 2
2716245 | 00 | gkwr 2
2716301 | 00 | gkwr 2
2716487 | 00 | gkwa 3
2716492 | 00 | gkwa 3
2716494 | 00 | gkwa 3
2716506 | 00 | gkwa 3
2716508 | 00 | gkwa 3
2717164 | 00 | gkwa 3
2717321 | 00 | gkwa 3
2717329 | 00 | gkwa 3
2717389 | 00 | gkwa 3
2717439 | 00 | gkwa 3
2717456 | 00 | gkwa 3
2717496 | 00 | gkwa 3
2717514 | 00 | gkwa 3
2717544 | 00 | gkwa 3
2717556 | 00 | gkwa 3
2726771 | 00 | gkwr 2
2726816 | 00 | gkwa 3
2726847 | 00 | gkwa 3
2726901 | 00 | gkwa 3
2726906 | 00 | gkwr 2
2726908 | 00 | gkwr 2
2726987 | 00 | gkwr 2
2727008 | 00 | gkwa 3
2727245 | 00 | gkwa 3
2727281 | 00 | gkwr 2
2727292 | 00 | gkwr 2
2727297 | 00 | gkwa 3
2727393 | 00 | gkwa 3
2727401 | 00 | gkwa 3
2727411 | 00 | gkwa 3
2727421 | 00 | gkwa 3
2727481 | 00 | gkwr 2
2727489 | 00 | gkwr 2
2727499 | 00 | gkwr 2
2727507 | 00 | gkwr 2
2728278 | 00 | gkwr 2
2728282 | 00 | gkwr 2
2728288 | 00 | gkwr 2
2728412 | 00 | gkwr 2
2728457 | 00 | gkwr 2
2728819 | 00 | gkwa 3
2728841 | 00 | gkwr 2
2728979 | 00 | gkwr 2
2728987 | 00 | gkwr 2
2728995 | 00 | gkwr 2
2729110 | 00 | gkwr 2
2729162 | 00 | gkwr 2
2729208 | 00 | gkwa 3
2729212 | 00 | gkwa 3
2729250 | 00 | gkwr 2
2729252 | 00 | gkwr 2
2744148 | 00 | cvr 11
2744166 | 00 | cvr 11
2744236 | 00 | cvr 23
2744306 | 00 | cvr 23
2744370 | 00 | cvr 24
2744380 | 00 | cvr 24
2744524 | 00 | cva 20
2744549 | 00 | cva 8
2744578 | 00 | cva 10
2744776 | 00 | cva 8
2744786 | 00 | cva 8
2744826 | 00 | cva 20
2744838 | 00 | cva 20
2744867 | 00 | cva 10
2744885 | 00 | cva 10
2744925 | 00 | cvr 24
2744960 | 00 | cvr 23
2744993 | 00 | cvr 11
2745449 | 00 | cvr 1
2745854 | 00 | cvr 1
2745900 | 00 | cva 1
2745930 | 00 | cvr 1
2745946 | 00 | cva 1
2745948 | 00 | cva 1
2745987 | 00 | cva 1
2746020 | 00 | cva 1
2746084 | 00 | cvr 1
2746334 | 00 | gkwa 3
2746589 | 00 | gkwr 2
2746663 | 00 | gkwr 2
2746677 | 00 | gkwr 2
2746706 | 00 | gkwr 2
2757151 | 00 | cvr 11
2757162 | 00 | cvr 11
2757166 | 00 | cvr 11
2757170 | 00 | cvr 11
2757234 | 00 | cva 20
2757319 | 00 | cva 20
2757323 | 00 | cva 20
2757327 | 00 | cva 20
2801410 | 01 | cvr 23
2801442 | 01 | cva 10
2801576 | 01 | cvr 23
2801651 | 01 | cva 10
2801829 | 01 | cvr 23
2801946 | 01 | cva 10
2802636 | 01 | cva 8
2802694 | 01 | cva 8
2802748 | 01 | cvr 24
2802867 | 01 | cva 8
2802980 | 01 | cva 8
2803033 | 01 | cvr 24
2803043 | 01 | cvr 24
2830787 | 00 | cva 1
2830800 | 01 | cva 1
2830823 | 00 | cva 1
2830835 | 00 | cvr 1
2830837 | 00 | cvr 1
2830862 | 01 | cvr 1
2830864 | 00 | cvr 1
2830890 | 00 | cva 1
2830894 | 00 | cva 1
2830910 | 00 | cvr 1
2830912 | 00 | cvr 1
2830922 | 00 | cva 1
2830944 | 01 | cva 1
2830948 | 00 | cva 1
2830956 | 00 | cvr 1
2830960 | 00 | cvr 1
2830976 | 01 | cvr 1
2830978 | 00 | cvr 1
2830996 | 00 | cva 1
2831021 | 00 | cva 1
2831025 | 00 | cva 1
2831033 | 00 | cvr 1
2831058 | 00 | cvr 1
2831060 | 00 | cvr 1
2831071 | 00 | cva 1
2831096 | 01 | cva 1
2831100 | 00 | cva 1
2831111 | 00 | cvr 1
2831136 | 01 | cvr 1
2831138 | 00 | cvr 1
2831149 | 00 | cva 1
2831151 | 00 | cva 1
2831176 | 01 | cva 1
2831178 | 00 | cva 1
2831210 | 01 | cvr 1
2831214 | 00 | cvr 1
2831220 | 00 | cvr 1
2831245 | 00 | cvr 1
2831247 | 00 | cvr 1
2831257 | 00 | cva 1
2831268 | 00 | cva 1
2831289 | 01 | cvr 1
2831293 | 01 | cvr 1
2831297 | 01 | cvr 1
2831306 | 00 | cvr 1
2831326 | 01 | cva 1
2831330 | 01 | cva 1
2831334 | 01 | cva 1
2831343 | 00 | cva 1
2831357 | 00 | cva 1
2831368 | 01 | cva 1
2831380 | 00 | cvr 1
2831391 | 01 | cvr 1
2831400 | 00 | cvr 1
2831427 | 00 | cvr 1
2831431 | 00 | cvr 1
2831439 | 00 | cva 1
2831464 | 00 | cva 1
2831468 | 00 | cva 1
2831476 | 00 | cvr 1
2831503 | 00 | cvr 1
2831505 | 00 | cvr 1
2831513 | 00 | cva 1
2831538 | 00 | cva 1
2831542 | 00 | cva 1
2831550 | 00 | cvr 1
2831564 | 01 | cvr 1
2831568 | 00 | cvr 1
2831576 | 00 | cva 1
2831590 | 01 | cva 1
2831594 | 00 | cva 1
2831602 | 00 | cvr 1
2831629 | 00 | cvr 1
2831631 | 00 | cvr 1
2831639 | 00 | cva 1
2831664 | 00 | cva 1
2831668 | 00 | cva 1
2831676 | 00 | cvr 1
2831703 | 00 | cvr 1
2831705 | 00 | cvr 1
2831713 | 00 | cva 1
2831738 | 00 | cva 1
2831742 | 00 | cva 1
2831752 | 00 | cva 1
2831756 | 00 | cva 1
2831768 | 01 | cva 1
2831772 | 00 | cva 1
2831788 | 01 | cvr 1
2831792 | 00 | cvr 1
2831928 | 00 | cvr 1
2831930 | 00 | cvr 1
2832153 | 00 | cva 1
2832173 | 00 | cvr 1
2832222 | 00 | cva 1
2832519 | 00 | cva 20
2832537 | 01 | cva 20
2832545 | 00 | cvr 11
2832563 | 01 | cvr 11
2832571 | 00 | cvr 11
2832575 | 00 | cvr 11
2832587 | 00 | cvr 11
2832599 | 00 | cva 20
2832601 | 00 | cva 20
2832617 | 01 | cva 20
2832619 | 00 | cva 20
2832625 | 00 | cvr 11
2832639 | 00 | cvr 11
2832641 | 01 | cvr 11
2832666 | 00 | cva 20
2832684 | 01 | cva 20
2832701 | 00 | cva 25
2832705 | 00 | cva 25
2832717 | 00 | cva 25
2832721 | 00 | cva 25
2832750 | 00 | cvr 11
2832754 | 00 | cvr 11
2832756 | 00 | cvr 11
2832776 | 01 | cvr 11
2832802 | 01 | cvr 11
2832812 | 01 | cva 20
2832818 | 01 | cva 20
2832824 | 01 | cvr 11
2832828 | 01 | cvr 11
2832850 | 01 | cva 20
2832975 | 00 | cvr 16
2832979 | 00 | cvr 16
2832991 | 00 | cvr 16
2832993 | 00 | cvr 16
2833008 | 00 | cva 20
2833033 | 01 | cva 20
2833035 | 00 | cva 20
2833044 | 00 | cvr 11
2833071 | 00 | cvr 11
2833075 | 01 | cvr 11
2833086 | 00 | cva 20
2833111 | 01 | cva 20
2833113 | 00 | cva 20
2833143 | 01 | cvr 11
2833147 | 00 | cvr 11
2833186 | 00 | cva 20
2833190 | 00 | cva 20
2833196 | 00 | cvr 11
2833221 | 00 | cvr 11
2833223 | 00 | cvr 11
2833237 | 00 | cva 20
2833245 | 00 | cva 20
2833270 | 00 | cva 20
2833274 | 00 | cva 20
2833282 | 00 | cvr 11
2833307 | 00 | cvr 11
2833309 | 00 | cvr 11
2833317 | 00 | cvr 11
2833342 | 00 | cvr 11
2833344 | 00 | cvr 11
2833352 | 00 | cva 20
2833377 | 00 | cva 20
2833381 | 00 | cva 20
2833389 | 00 | cvr 11
2833414 | 00 | cvr 11
2833416 | 00 | cvr 11
2833426 | 00 | cva 20
2833437 | 00 | cva 20
2833453 | 00 | cva 20
2833457 | 00 | cva 20
2833468 | 01 | cva 20
2833479 | 00 | cvr 11
2833483 | 00 | cvr 11
2833508 | 01 | cvr 11
2833510 | 00 | cvr 11
2833572 | 01 | cvr 11
2833688 | 00 | cva 20
2833708 | 00 | cva 20
2834167 | 00 | cva 20
2834175 | 00 | cvr 11
2834213 | 00 | cvr 11
2834238 | 00 | cva 20
2903106 | F | brr 1
2903216 | 00 | brr 1
2924538 | F | bra 3
2924625 | F | brr 1
2924682 | F | bra 3
2924960 | F | brr 1
2925013 | F | bra 3
2925015 | 00 | bra 3
2925036 | F | bra 3
2925057 | F | brr 1
2925076 | F | bra 3
2925095 | F | brr 1
2925200 | F | brr 1
2925247 | F | brr 1
2925296 | F | bra 3
2925317 | F | bra 3

# IfcFlowFitting: NLRS_50_PIF_UN_draadverbinding bocht_gen_ISR:std (3)
In: 00
Type - Classification: 5- (Uniformat); Material: PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIF_UN_draadverbinding bocht_gen_ISR:std:...) | Group
1269520 | cvr 5
1269581 | cva 6
1269650 | cva 6

# IfcFlowFitting: NLRS_50_PIF_UN_draadverbinding t-stuk_gen_ISR:std, NLRS_50_PIF_UN_draadverbinding t-stuk_gen_ISR:std:1269509
In: 00
Type - Classification: 5- (Uniformat); Material: <Unnamed>, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs; Group: cvr 5
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2

# IfcFlowFitting: NLRS_50_PIF_UN_draadverbinding verloop bi-bi_gen_ISR:std (4)
In: 00
Type - Classification: 5- (Uniformat); Material: <Unnamed>, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIF_UN_draadverbinding verloop bi-bi_gen_ISR:std:...) | Group
1269517 | cvr 5
1269522 | cvr 5
1269583 | cva 6
1269652 | cva 6

# IfcFlowFitting: NLRS_50_PIF_UN_koper soldeerverbinding bocht_gen_ISR:std (352)
Type - Classification: 5- (Uniformat); Material: ISR_koper
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIF_UN_koper soldeerverbinding bocht_gen_ISR:std:...) | In | Group
2277902 | 01 | kw 3
2277906 | 01 | kw 3
2278580 | 01 | kw 3
2278582 | 01 | kw 3
2284278 | 00 | kw 3
2284282 | 00 | kw 3
2284364 | 00 | kw 3
2284366 | 00 | kw 3
2285916 | 00 | kw 3
2288760 | 00 | kw 3
2288807 | 00 | kw 3
2288809 | 00 | kw 3
2288841 | 00 | kw 3
2288843 | 00 | kw 3
2289001 | 00 | kw 3
2289355 | 00 | kw 3
2289654 | 00 | kw 3
2289667 | 00 | kw 3
2289900 | 01 | kw 3
2289902 | 01 | kw 3
2289932 | 01 | kw 3
2289934 | 01 | kw 3
2289964 | 01 | kw 3
2289966 | 01 | kw 3
2289994 | 01 | kw 3
2289996 | 01 | kw 3
2290404 | 01 | kw 3
2290812 | 01 | kw 3
2290828 | 01 | kw 3
2291053 | 00 | kw 3
2291067 | 00 | kw 3
2291100 | 00 | kw 3
2291112 | 00 | kw 3
2291906 | 01 | kw 3
2291973 | 01 | kw 3
2292037 | 01 | kw 3
2292047 | 01 | kw 3
2292374 | 01 | kw 3
2292386 | 01 | kw 3
2292568 | 01 | kw 3
2292572 | 01 | kw 3
2292576 | 01 | kw 3
2506521 | 00 | kw 3
2508333 | 00 | ww 2
2508351 | 00 | ww 2
2508444 | 00 | ww 2
2508446 | 00 | ww 2
2508608 | 00 | kw 3
2508906 | 00 | ww 2
2509390 | 00 | ww 2
2509404 | 00 | ww 2
2509439 | 00 | ww 2
2509536 | 00 | ww 2
2509546 | 00 | ww 2
2509634 | 00 | ww 2
2510134 | 00 | ww 2
2510142 | 00 | ww 2
2510223 | 00 | ww 2
2510310 | 00 | ww 2
2510312 | 00 | ww 2
2511657 | 00 | ww 1
2511681 | 00 | ww 1
2511871 | 00 | ww 1
2511929 | 00 | ww 1
2511933 | 00 | ww 1
2511992 | 00 | ww 1
2512017 | 00 | ww 1
2512076 | 00 | ww 1
2512104 | 00 | ww 1
2512965 | 00 | ww 3
2513038 | 00 | ww 3
2514026 | 00 | ww 3
2514358 | 00 | ww 3
2514371 | 00 | ww 3
2514381 | F | ww 3
2515254 | 01 | ww 5
2515896 | 00 | kw 3
2515978 | 00 | ww 5
2516588 | 00 | ww 5
2516730 | 00 | ww 5
2516743 | 00 | ww 5
2516982 | 00 | ww 5
2517297 | F | kw 3
2517304 | F | kw 3
2517306 | 00 | kw 3
2517354 | 00 | kw 3
2517442 | 00 | kw 3
2517511 | F | kw 3
2517572 | 00 | kw 3
2517606 | 00 | kw 3
2517736 | F | kw 3
2517797 | 00 | kw 3
2518037 | 00 | kw 3
2518083 | 00 | kw 3
2518609 | 00 | kw 3
2518621 | 00 | kw 3
2518677 | 00 | kw 3
2518752 | 00 | kw 3
2518822 | 00 | kw 3
2518976 | F | kw 3
2519037 | 00 | kw 3
2519077 | 01 | kw 3
2519447 | 00 | kw 3
2519476 | 00 | kw 3
2519505 | F | kw 3
2519544 | F | kw 3
2523979 | F | kw 3
2524418 | F | kw 3
2524422 | F | kw 3
2524574 | 00 | kw 3
2524578 | F | kw 3
2524596 | F | kw 3
2524645 | 00 | kw 3
2524730 | 00 | kw 3
2524821 | 00 | kw 3
2524966 | 00 | kw 3
2525002 | 00 | kw 3
2525018 | F | kw 3
2529494 | 00 | kw 3
2529547 | F | kw 3
2529549 | F | kw 3
2529906 | 00 | kw 3
2535399 | 00 | kw 3
2535403 | 00 | kw 3
2537255 | 01 | kw BSH
2537268 | 01 | kw BSH
2537279 | 00 | kw BSH
2537362 | 00 | kw BSH
2537697 | 01 | kw BSH
2537749 | 01 | kw BSH
2538083 | 00 | kw BSH
2538715 | 00 | kw BSH
2538772 | F | kw BSH
2538787 | 00 | kw BSH
2538841 | 00 | kw BSH
2538970 | F | kw BSH
2539071 | F | kw BSH
2539081 | F | kw BSH
2539083 | 00 | kw BSH
2539149 | 00 | kw BSH
2545617 | 01 | kw 3
2545657 | 01 | kw 3
2545672 | 01 | kw 3
2545784 | 00 | kw 3
2545835 | F | kw 3
2545954 | F | kw 3
2545958 | 01 | kw 3
2546422 | 00 | kw 3
2546647 | 00 | kw 3
2546953 | 00 | kw 3
2547806 | F | kw 3
2547977 | F | kw 3
2548002 | 00 | kw 3
2548071 | F | kw 3
2553603 | 00 | ww 5
2553640 | 01 | ww 5
2553658 | 00 | ww 5
2553831 | 00 | ww 5
2553835 | 00 | ww 5
2554091 | 00 | ww 5
2554101 | 00 | ww 5
2554105 | 00 | ww 5
2555644 | 00 | kw 3
2555658 | 00 | kw 3
2574011 | 01 | ww 12
2574017 | 01 | ww 12
2574021 | 01 | ww 12
2574051 | 01 | kw 3
2574077 | 01 | kw 3
2574211 | 01 | kw 3
2574283 | 01 | kw 3
2574472 | 01 | kw 3
2574659 | 00 | kw 3
2574960 | 00 | kw 3
2574981 | F | kw 3
2574993 | 01 | kw 3
2575144 | 01 | kw 3
2674966 | 00 | kw 3
2675014 | F | kw 3
2675039 | 00 | kw 3
2675068 | 00 | kw 3
2726527 | 00 | gkwr 2
2728015 | 00 | gkwa 3
2728019 | 00 | gkwa 3
2728074 | 00 | gkwr 2
2728128 | 00 | gkwa 3
2728180 | 00 | gkwa 3
2742043 | 00 | ww 10
2742063 | 00 | ww 10
2742067 | 00 | ww 10
2742261 | 00 | ww 10
2742275 | 00 | ww 10
2742364 | 00 | kw 3
2742375 | 00 | kw 3
2742478 | 00 | kw 3
2777036 | 00 | ww 15
2777067 | 00 | ww 14
2777082 | 00 | ww 14
2777127 | 00 | ww 13
2777140 | 00 | ww 13
2777223 | 01 | ww 13
2777622 | 01 | ww 14
2777642 | 01 | ww 15
2777662 | 01 | ww 16
2777684 | 01 | ww 18
2777743 | 01 | ww 18
2777766 | 01 | ww 17
2777789 | 01 | ww 16
2777812 | 01 | ww 15
2777835 | 01 | ww 14
2777858 | 01 | ww 13
2778146 | 00 | ww 16
2778148 | 00 | ww 18
2778150 | 00 | ww 18
2778152 | 00 | ww 17
2778154 | 00 | ww 17
2778166 | 01 | ww 17
2778239 | 01 | ww 13
2778241 | 01 | ww 13
2778245 | 01 | ww 14
2778247 | 01 | ww 14
2778249 | 01 | ww 15
2778251 | 00 | ww 15
2778253 | 01 | ww 16
2778255 | 00 | ww 16
2778257 | 01 | ww 18
2778259 | 01 | ww 18
2778261 | 01 | ww 17
2778263 | 01 | ww 17
2778305 | 00 | ww 28
2778307 | 00 | ww 27
2778309 | 00 | ww 27
2778311 | 00 | ww 26
2778313 | 00 | ww 26
2778323 | 01 | ww 26
2778339 | 01 | ww 27
2778347 | 01 | ww 28
2778355 | 01 | ww 29
2778363 | 01 | ww 31
2778371 | 01 | ww 31
2778375 | 01 | ww 30
2778379 | 01 | ww 29
2778383 | 01 | ww 28
2778387 | 01 | ww 27
2778391 | 01 | ww 26
2778407 | 00 | ww 29
2778409 | 00 | ww 31
2778411 | 00 | ww 31
2778413 | 00 | ww 30
2778415 | 00 | ww 30
2778425 | 01 | ww 30
2778429 | 01 | ww 26
2778431 | 01 | ww 26
2778433 | 01 | ww 27
2778435 | 01 | ww 27
2778437 | 01 | ww 28
2778439 | 00 | ww 28
2778441 | 01 | ww 29
2778443 | 00 | ww 29
2778445 | 01 | ww 31
2778447 | 01 | ww 31
2778449 | 01 | ww 30
2778451 | 01 | ww 30
2778942 | 01 | kw 3
2779200 | 01 | kw 3
2779375 | 01 | kw 3
2779424 | 01 | kw 3
2779662 | 01 | ww 10
2779674 | 01 | ww 10
2779686 | 01 | ww 10
2779777 | 01 | ww 10
2779790 | 01 | ww 10
2779930 | 01 | ww 10
2779981 | 01 | ww 10
2780201 | 00 | ww 10
2780205 | 01 | ww 10
2780209 | 01 | ww 10
2782894 | 01 | ww 10
2785172 | 01 | ww 10
2785185 | 01 | ww 10
2785366 | 01 | ww 10
2785388 | 01 | ww 10
2785440 | 01 | ww 10
2785458 | 01 | ww 10
2785475 | 01 | ww 10
2786055 | 01 | ww 4
2786180 | 01 | ww 4
2786255 | 01 | kw 3
2786402 | 01 | kw 3
2786703 | 01 | kw 3
2786718 | 01 | kw 3
2786728 | 00 | kw 3
2786887 | 00 | kw 3
2787044 | 00 | kw 3
2787052 | 00 | kw 3
2787211 | 00 | kw 3
2787215 | 00 | kw 3
2787472 | 01 | kw 3
2787484 | 01 | kw 3
2787817 | 01 | kw 3
2787993 | 00 | kw 3
2788105 | 01 | kw 3
2788274 | 01 | kw 3
2788525 | 01 | kw 3
2788688 | 00 | kw 3
2788700 | 00 | kw 3
2788853 | 01 | kw 3
2789005 | 00 | kw 3
2789414 | 00 | kw 3
2789536 | 01 | kw 3
2789544 | 01 | kw 3
2789644 | 01 | kw 3
2789646 | 01 | kw 3
2789776 | 01 | kw 3
2789832 | 01 | kw 3
2789842 | 01 | kw 3
2789850 | 01 | kw 3
2790013 | 01 | kw 3
2790099 | 00 | kw 3
2790554 | 01 | kw 3
2790757 | 01 | kw 3
2790770 | 01 | kw 3
2790830 | 01 | kw 3
2791095 | 01 | kw 3
2791112 | 01 | kw 3
2791163 | 01 | kw 3
2791385 | 00 | kw 3
2791660 | 00 | kw 3
2791862 | 00 | kw 3
2792602 | 00 | kw 3
2792606 | F | kw 3
2793759 | 01 | kw 3
2793771 | 01 | kw 3
2793779 | 01 | kw 3
2793820 | 01 | kw 3
2793822 | 01 | kw 3
2793963 | 00 | kw 3
2793973 | 00 | kw 3
2794197 | 00 | kw 3
2794205 | 01 | kw 3
2794209 | 00 | kw 3
2794474 | 00 | kw 3
2794492 | 00 | kw 3
2795782 | 00 | ww 5
2795794 | 00 | ww 5
2796051 | 00 | ww 5
2796144 | F | kw 3
2796209 | F | kw 3
2796211 | 00 | kw 3
2797565 | F | kw BSH
2797591 | F | kw BSH
2800618 | 01 | kw 3

# IfcFlowFitting: NLRS_50_PIF_UN_koper soldeerverbinding t-stuk_gen_ISR:std (108)
Type - Classification: 5- (Uniformat); Material: ISR_koper
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIF_UN_koper soldeerverbinding t-stuk_gen_ISR:std:...) | In | Group
2277924 | 01 | kw 3
2284295 | 00 | kw 3
2284370 | 00 | kw 3
2288777 | 00 | kw 3
2288813 | 00 | kw 3
2288847 | 00 | kw 3
2288995 | 00 | kw 3
2289351 | 00 | kw 3
2289674 | 00 | kw 3
2289695 | 00 | kw 3
2289858 | 01 | kw 3
2289906 | 01 | kw 3
2289938 | 01 | kw 3
2289970 | 01 | kw 3
2290000 | 01 | kw 3
2290437 | 01 | kw 3
2290463 | 01 | kw 3
2290487 | 01 | kw 3
2290512 | 01 | kw 3
2290851 | 01 | kw 3
2508556 | 00 | ww 2
2509051 | 00 | ww 2
2509918 | 00 | ww 2
2511923 | 00 | ww 1
2512046 | 00 | ww 1
2514052 | 00 | ww 3
2516784 | 00 | ww 5
2517228 | F | kw 3
2517343 | F | kw 3
2517432 | F | kw 3
2517482 | F | kw 3
2517566 | F | kw 3
2517600 | F | kw 3
2517720 | F | kw 3
2517787 | F | kw 3
2517960 | 00 | kw 3
2517988 | F | kw 3
2518027 | F | kw 3
2518073 | F | kw 3
2518307 | F | kw 3
2518667 | F | kw 3
2518748 | F | kw 3
2518818 | F | kw 3
2518838 | F | kw 3
2518966 | F | kw 3
2519027 | F | kw 3
2519101 | 00 | kw 3
2519361 | 00 | kw 3
2523961 | F | kw 3
2524398 | F | kw 3
2524408 | F | kw 3
2524512 | F | kw 3
2524586 | F | kw 3
2524720 | F | kw 3
2524811 | F | kw 3
2524954 | F | kw 3
2524992 | F | kw 3
2525006 | F | kw 3
2529838 | F | kw 3
2529910 | F | kw 3
2538957 | F | kw BSH
2538994 | F | kw BSH
2539026 | F | kw BSH
2539143 | F | kw BSH
2545825 | F | kw 3
2545892 | 00 | kw 3
2546947 | 00 | kw 3
2547758 | F | kw 3
2548026 | F | kw 3
2555634 | F | kw 3
2555648 | F | kw 3
2574205 | 01 | kw 3
2574989 | F | kw 3
2575022 | F | kw 3
2674960 | F | kw 3
2675035 | F | kw 3
2675064 | F | kw 3
2727961 | 00 | gkwa 3
2728063 | 00 | gkwr 2
2728084 | 00 | gkwr 2
2728174 | 00 | gkwa 3
2742468 | F | kw 3
2779097 | 01 | kw 3
2779369 | 01 | kw 3
2779881 | 01 | ww 10
2784726 | 01 | ww 10
2785417 | 01 | ww 10
2786398 | 01 | kw 3
2786765 | 01 | kw 3
2787205 | 00 | kw 3
2787532 | 01 | kw 3
2787989 | 00 | kw 3
2788264 | 01 | kw 3
2788593 | 00 | kw 3
2788974 | 00 | kw 3
2789986 | 01 | kw 3
2790089 | 00 | kw 3
2790826 | 01 | kw 3
2791108 | 00 | kw 3
2791381 | F | kw 3
2791696 | 00 | kw 3
2793816 | 01 | kw 3
2793996 | 01 | kw 3
2794120 | 00 | kw 3
2794456 | 00 | kw 3
2796041 | 00 | ww 5
2797695 | F | kw 3
2800608 | 01 | kw 3

# IfcFlowFitting: NLRS_50_PIF_UN_koper soldeerverbinding verloop bi-bu_gen_ISR:std (248)
Type - Classification: 5- (Uniformat); Material: ISR_koper
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
