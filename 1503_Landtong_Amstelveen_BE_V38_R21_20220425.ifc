Properties of the parts of a building model (IFC2X3), part 1 of 13

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 1503
Time: 2022-05-10T15:18:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.50.27 - Exporter 21.2.1.0 - Alternate UI 21.2.1.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 10 15:18:04 2022 * Host: SRV-WRVT01 * Database: C:\Users\BIM-RV~1\AppData\Local\Temp\4\a7987013-6eab-4c6a-8a6e-cbe68b7825cc\c5142a9e-b3fc-4d08-ab6c-c1bd45b533b3\ifc * Database version: 5507 * Database creation date: Tue May 10 15:17:09 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 10 15:17:09 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 10 15:17:09 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 1503
LongName: Landtong; Phase: Bestek

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 4
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Verdieping (4)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
F | F | -570
00 | 00 | 3.29936e-13
01 | 01 | 3875
02 | 02 | 7600

# IfcBuildingElementProxy: 10.LBK School - TROX Technik (NED) #bsasj5o#:Standard, 10.LBK School - TROX Technik (NED) #bsasj5o#:Standard:2683447
In: 01
Type - Material: 0.094_0.094_0.094_1_0.502_0.502_0.502_1_1_1_1_1_128_0_0_0_1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TROX Technik (NED)
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Material: 0.094_0.094_0.094_1_0.502_0.502_0.502_1_1_1_1_1_128_0_0_0_1, 0.91_0.95_0.9_1_0.91_0.95_0.9_1_0.91_0.95_0.9_1_24_0_0_0_1, 0.969_0.984_0.961_1_0.969_0.984_0.961_1_0.969_0.984_0.961_1_24_0_0_0_1, 0.18_0.188_0.196_1_0.18_0.188_0.196_1_0.18_0.188_0.196_1_64_0_0_0_1, <Unnamed>; Group: mvaf 5; mvaz 1; mvt lbk1; mvr 5
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2

# IfcBuildingElementProxy: 20.X-CUBE - TROX Technik (NED) #it9jqg0#:Standard, 20.X-CUBE - TROX Technik (NED) #it9jqg0#:Standard:2697072
In: 02
Type - Material: 0.969_0.984_0.961_1_0.969_0.984_0.961_1_0.969_0.984_0.961_1_24_0_0_0_1
Type - Pset_ManufacturerTypeInformation - Manufacturer: TROX Technik (NED)
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Material: 0.969_0.984_0.961_1_0.969_0.984_0.961_1_0.969_0.984_0.961_1_24_0_0_0_1, 0.094_0.094_0.094_1_0.502_0.502_0.502_1_1_1_1_1_128_0_0_0_1, 0.18_0.188_0.196_1_0.18_0.188_0.196_1_0.18_0.188_0.196_1_64_0_0_0_1, 0.91_0.95_0.9_1_0.91_0.95_0.9_1_0.91_0.95_0.9_1_24_0_0_0_1, <Unnamed>; Group: mvaf 6; mvaz 6; mvt 2; mvr 5
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2

# IfcBuildingElementProxy: Grootverbruik Alliander1:Grootverbruik Alliander, Grootverbruik Alliander1:Grootverbruik Alliander:2755812
In: 00
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_BuildingElementProxyCommon - Reference: Grootverbruik Alliander; sets with these values: 2
Pset_ProvisionForVoid - Width: 1000 mm; Height: 250 mm; Depth: 1000 mm

# IfcBuildingElementProxy: Grootverbruik Alliander2:Grootverbruik Alliander, Grootverbruik Alliander2:Grootverbruik Alliander:2758406
In: 01
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_BuildingElementProxyCommon - Reference: Grootverbruik Alliander; sets with these values: 2
Pset_ProvisionForVoid - Width: 1000 mm; Height: 250 mm; Depth: 1000 mm

# IfcBuildingElementProxy: NLRS_00_nulpunt_Fore:NLRS_00_nulpunt_Fore, NLRS_00_nulpunt_Fore:NLRS_00_nulpunt_Fore:960195
In: 00
Type - Material: Oranje
Type - Pset_ManufacturerTypeInformation - Manufacturer: Fore Installatie Adviseurs
Type - Pset_ProductRequirements - Category: Generic Models
Material: Oranje, Grijs
Pset_BuildingElementProxyCommon - Reference: NLRS_00_nulpunt_Fore; sets with these values: 2

# IfcBuildingElementProxy: NLRS_50_ME_LB_platenwarmtewisselaar_gen_ISR1:320 kW, NLRS_50_ME_LB_platenwarmtewisselaar_gen_ISR1:320 kW:1246538
In: 00
Type - Classification: 50.00 (Uniformat); Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_BuildingElementProxyCommon - Reference: 320 kW; sets with these values: 2
Group: gkwa 2; gkwr 4; gkwr 1

# IfcBuildingElementProxy: NLRS_50_ME_UN_Boilervat_PUB2_DS:500 Liter, NLRS_50_ME_UN_Boilervat_PUB2_DS:500 Liter:2733843
In: 00
Type - Classification: 50.00 (Uniformat); Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Nibe
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_BuildingElementProxyCommon - Reference: 500 Liter; sets with these values: 2
Group: ww 10; kw 3; cvr 5; cva 6

# IfcBuildingElementProxy: NLRS_50_ME_UN_Buffervat_danfoss:Horos 500 ltr, NLRS_50_ME_UN_Buffervat_danfoss:Horos 500 ltr:1266300
In: 00
Type - Classification: 50.00 (Uniformat); Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Horos
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_BuildingElementProxyCommon - Reference: Horos 500 ltr; sets with these values: 2
Group: cvr 6; cva 5; cva 7; cvr 7 (1); cva 3; cvr 3

# IfcBuildingElementProxy: NLRS_50_ME_verzamelput DN1200-enkelzijdig_R20:NLRS_50_ME_verzamelput DN1200-enkelzijdig_R20 (3)
In: F
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Muovitech
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_BuildingElementProxyCommon - Reference: NLRS_50_ME_verzamelput DN1200-enkelzijdig_R20; sets with these values: 2
Name (NLRS_50_ME_verzamelput DN1200-enkelzijdig_R20:NLRS_50_ME_verzamelput DN1200-enkelzijdig_R20:...) | Group
2828010 | bra 2; brr 3
2895162 | bra 2; brr 3; bra 3; brr 1
2897042 | bra 3; brr 1

# IfcBuildingElementProxy: NLRS_51_ME_UN_wartepomp_Thermia Mega.0011:L-XL (3)
In: 00
Type - Classification: 51.00 (Uniformat); Material: Steel, Cast (8), Plastic, Opaque Black, Steel, Wrought
Type - Pset_ManufacturerTypeInformation - Manufacturer: Thermia
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_BuildingElementProxyCommon - Reference: L-XL; sets with these values: 2
Group: cvr 5; cva 6; cva 3; cvr 3; bra 3; brr 1
Name (NLRS_51_ME_UN_wartepomp_Thermia Mega.0011:L-XL:...) | Material
2910811 | Pset_ProvisionForVoid - Width: 1614 mm; Height: 762.3 mm; Depth: 1614 mm
2911694 | Steel, Cast, Plastic, Opaque Black, Steel, Wrought
2911759 | Steel, Cast, Plastic, Opaque Black, Steel, Wrought

# IfcBuildingElementProxy: NLRS_56_UN_ME_vloerverwarmingsverdeler:600x700x150 (32)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_BuildingElementProxyCommon - Reference: 600x700x150; sets with these values: 2
Name (NLRS_56_UN_ME_vloerverwarmingsverdeler:600x700x150:...) | In | Group
2129132 | 01 | cva 1; cvr 1 | Pset_ProvisionForVoid - Width: 700 mm; Height: 400 mm; Depth: 700 mm
2129184 | 01 | cva 1; cvr 1
2129434 | 01 | cvr 11; cva 20
2129448 | 01 | cvr 11; cva 20
2129640 | 01 | cvr 11; cva 20
2130943 | 01 | cvr 11; cva 20
2131526 | 01 | cva 1; cvr 1
2132531 | 01 | cva 1; cvr 1
2145387 | 00 | cvr 11; cva 20
2145441 | 00 | cvr 11; cva 20
2145480 | 00 | cva 1; cvr 1
2145792 | 00 | cva 1; cvr 1
2145839 | 00 | cvr 11; cva 20
2146070 | 00 | cvr 11; cva 20
2146162 | 00 | cvr 11; cva 20
2146923 | 00 | cvr 11; cva 20
2147134 | 00 | cva 1; cvr 1
2147828 | 00 | cvr 11; cva 20
2246069 | 00 | cva 25; cvr 16
2249536 | 00 | cvr 11; cva 20
2250182 | 00 | cva 1; cvr 1
2250211 | 00 | cva 1; cvr 1
2250392 | 00 | cva 1; cvr 1
2250627 | 00 | cva 1; cvr 1
2251264 | 00 | cvr 11; cva 20
2252740 | 01 | cva 1; cvr 1
2253033 | 01 | cva 1; cvr 1
2253147 | 01 | cvr 11; cva 20
2254304 | 01 | cva 1; cvr 1
2301038 | 01 | cvr 11; cva 20
2301657 | 01 | cvr 11; cva 20
2565258 | 01 | cva 1; cvr 1

# IfcBuildingElementProxy: NLRS_57_DA_LB_Brandklep recht_Trox_FK2_EU:huislengte 305 (2)
In: 01
Type - Classification: 57.00 (Uniformat); Material: <Unnamed> (6)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Trox
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: huislengte 305; sets with these values: 2
Name (NLRS_57_DA_LB_Brandklep recht_Trox_FK2_EU:huislengte 305:...) | Width (mm) = Depth (mm) | Height (mm) | Group
2597398 | 510 | 760 | mvr 5
2602918 | 360 | 810 | mvt lbk1

# IfcBuildingElementProxy: NLRS_57_DA_LB_Brandklep recht_Trox_FK2_EU:huislengte 500 (14)
Type - Classification: 57.00 (Uniformat); Material: <Unnamed> (8)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Trox
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: huislengte 500; sets with these values: 2
Name (NLRS_57_DA_LB_Brandklep recht_Trox_FK2_EU:huislengte 500:...) | In | Width (mm) = Depth (mm) | Height (mm) | Group
2437018 | 01 | 510 | 5 | mvt 2
2587735 | 00 | 1760 | 610 | mvr 5
2588773 | 00 | 510 | 860 | mvr 5
2588950 | 00 | 410 | 810 | mvr 5
2589175 | 00 | 610 | 610 | mvt lbk1
2592016 | 00 | 410 | 510 | mvr 5
2592753 | 00 | 360 | 860 | mvr 5
2593093 | 00 | 360 | 460 | mvr 5
2594147 | 00 | 310 | 810 | mvt lbk1
2596740 | 01 | 510 | 760 | mvt 2
2599752 | 01 | 310 | 560 | mvr 5
2627473 | 01 | 460 | 1260 | mvr 5
2629050 | 01 | 460 | 5 | mvr 5
2747996 | 00 | 460 | 5 | mvt lbk1

# IfcBuildingElementProxy: NLRS_57_DA_LB_Brandklep rond_Trox_FK_EU:FKRS (14)
Type - Classification: 57.00 (Uniformat); Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Trox
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: FKRS; sets with these values: 2
Name (NLRS_57_DA_LB_Brandklep rond_Trox_FK_EU:FKRS:...) | In | Diameter (mm) | Group
2563156 | 02 | 310 | mvt lbk1
2585965 | 00 | 310 | mvr 5
2589539 | 00 | 310 | mvt lbk1
2590744 | 00 | 350 | mvr 5
2591081 | 00 | 310 | mvt lbk1
2591627 | 00 | 310 | mvt lbk1
2592198 | 00 | 310 | mvr 5
2592386 | 00 | 245 | mvr 5
2592653 | 00 | 310 | mvt lbk1
2598696 | 00 | 350 | mvt lbk1
2599486 | 01 | 245 | mvr 5
2602654 | 01 | 95 | mvr 5
2603867 | 02 | 310 | mvr 5
2772259 | 00 | 245 | mvr 5

# IfcBuildingElementProxy: NLRS_57_DA_LB_Geluiddemper_Trox_CS:CS-025 L1500 (61)
Type - Classification: 57.00 (Uniformat); Material: <Unnamed> (5)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Trox
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: CS-025 L1500; sets with these values: 2
Name (NLRS_57_DA_LB_Geluiddemper_Trox_CS:CS-025 L1500:...) | In | Group | Material
2057633 | 00 | mvr 5 | Pset_ProvisionForVoid - Width: 1500 mm; Depth: 1500 mm
2069165 | 00 | mvt lbk1 | <Unnamed>
2073313 | 00 | mvt lbk1 | Pset_ProvisionForVoid - Width: 1500 mm; Depth: 1500 mm
2084244 | 00 | mvt lbk1 | <Unnamed>
2084324 | 00 | mvt lbk1 | <Unnamed>
2126883 | 00 | mvt lbk1 | <Unnamed>
2156561 | 00 | mvt lbk1 | <Unnamed>
2157964 | 00 | mvt lbk1 | <Unnamed>
2158120 | 00 | mvt lbk1 | <Unnamed>
2158246 | 00 | mvt lbk1 | <Unnamed>
2161246 | 00 | mvr 5 | <Unnamed>
2183571 | 01 | mvr 5 | <Unnamed>
2184157 | 01 | mvr 5 | <Unnamed>
2190143 | 01 | mvr 5 | <Unnamed>
2190556 | 01 | mvt lbk1 | <Unnamed>
2190732 | 01 | mvt lbk1 | <Unnamed>
2190817 | 01 | mvt lbk1 | <Unnamed>
2192011 | 01 | mvr 5 | <Unnamed>
2192109 | 01 | mvr 5 | <Unnamed>
2193165 | 01 | mvt lbk1 | <Unnamed>
2193371 | 01 | mvr 5 | <Unnamed>
2194209 | 01 | mvr 5 | <Unnamed>
2194806 | 01 | mvt lbk1 | <Unnamed>
2195404 | 01 | mvt lbk1 | <Unnamed>
2195498 | 01 | mvt lbk1 | <Unnamed>
2197515 | 01 | mvt lbk1 | <Unnamed>
2198452 | 01 | mvr 5 | <Unnamed>
2198662 | 01 | mvr 5 | <Unnamed>
2199814 | 01 | mvr 5 | Pset_ProvisionForVoid - Width: 1500 mm; Depth: 1500 mm
2200916 | 01 | mvr 5 | <Unnamed>
2202121 | 01 | mvt lbk1 | <Unnamed>
2203190 | 01 | mvr 5 | <Unnamed>
2205391 | 01 | mvt lbk1 | <Unnamed>
2207057 | 01 | mvt lbk1 | <Unnamed>
2207141 | 01 | mvr 5 | <Unnamed>
2214513 | 01 | mvr 5 | <Unnamed>
2216671 | 00 | mvr 5 | <Unnamed>
2222857 | 00 | mvt lbk1 | Pset_ProvisionForVoid - Width: 1500 mm; Depth: 1500 mm
2226599 | 00 | mvr 5 | <Unnamed>
2229496 | 00 | mvt lbk1 | <Unnamed>
2230233 | 00 | mvr 5 | <Unnamed>
2232164 | 00 | mvr 5 | <Unnamed>
2306717 | 00 | mvt lbk1 | <Unnamed>
2308574 | 00 | mvr 5 | Pset_ProvisionForVoid - Width: 1500 mm; Depth: 1500 mm
2313564 | 00 | mvr 5 | Pset_ProvisionForVoid - Width: 1500 mm; Depth: 1500 mm
2314923 | 01 | mvt lbk1 | <Unnamed>
2315420 | 00 | mvr 5 | <Unnamed>
2333176 | 00 | mvt lbk1 | <Unnamed>
2333210 | 00 | mvt lbk1 | <Unnamed>
2338307 | 00 | mvr 5 | <Unnamed>
2338363 | 00 | mvr 5 | <Unnamed>
2436309 | 01 | mvt 2 | <Unnamed>
2436379 | 01 | mvt 2 | <Unnamed>
2525576 | 00 | mvr 5 | <Unnamed>
2525843 | 00 | mvr 5 | <Unnamed>
2563803 | 02 | mvt lbk1 | <Unnamed>
2581705 | 00 | mvr 5 | <Unnamed>
2584095 | 00 | mvr 5 | <Unnamed>
2584992 | 00 | mvr 5 | <Unnamed>
2607013 | 02 | mvr 5 | <Unnamed>
2775456 | 00 | mvr 5 | <Unnamed>

# IfcBuildingElementProxy: NLRS_57_DA_LB_Geluiddemper_Trox_CS:CS-050 L1000 (31)
Type - Classification: 57.00 (Uniformat); Material: <Unnamed> (5)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Trox
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: CS-050 L1000; sets with these values: 2
Name (NLRS_57_DA_LB_Geluiddemper_Trox_CS:CS-050 L1000:...) | In | Group | Material
2059686 | 00 | mvr 5 | Pset_ProvisionForVoid - Width: 1000 mm; Depth: 1000 mm
2077953 | 00 | mvt lbk1 | Pset_ProvisionForVoid - Width: 1000 mm; Depth: 1000 mm
2202758 | 01 | mvt lbk1 | Pset_ProvisionForVoid - Width: 1000 mm; Depth: 1000 mm
2206223 | 01 | mvr 5 | Pset_ProvisionForVoid - Width: 1000 mm; Depth: 1000 mm
2311879 | 00 | mvt lbk1 | Pset_ProvisionForVoid - Width: 1000 mm; Depth: 1000 mm
2316300 | 00 | mvr 5 | <Unnamed>
2318951 | 00 | mvr 5 | <Unnamed>
2319017 | 00 | mvr 5 | <Unnamed>
2320134 | 00 | mvr 5 | Pset_ProvisionForVoid - Width: 1000 mm; Depth: 1000 mm
2320137 | 00 | mvr 5 | <Unnamed>
2322255 | 00 | mvt lbk1 | <Unnamed>
2322540 | 00 | mvt lbk1 | <Unnamed>
2322624 | 00 | mvt lbk1 | <Unnamed>
2323059 | 00 | mvt lbk1 | <Unnamed>
2323507 | 00 | mvt lbk1 | Pset_ProvisionForVoid - Width: 1000 mm; Depth: 1000 mm
2323510 | 00 | mvt lbk1 | <Unnamed>
2323517 | 00 | mvt lbk1 | Pset_ProvisionForVoid - Width: 1000 mm; Depth: 1000 mm
2326121 | 00 | mvr 5 | <Unnamed>
2327632 | 00 | mvr 5 | <Unnamed>
2329005 | 00 | mvt lbk1 | <Unnamed>
2334412 | 00 | mvt lbk1 | <Unnamed>
2436274 | 01 | mvt 2 | <Unnamed>
2436277 | 01 | mvt 2 | <Unnamed>
2436280 | 01 | mvt 2 | Pset_ProvisionForVoid - Width: 1000 mm; Depth: 1000 mm
2576247 | 00 | mvr 5 | <Unnamed>
2577995 | 00 | mvr 5 | <Unnamed>
2582619 | 00 | mvt lbk1 | <Unnamed>
2582701 | 00 | mvt lbk1 | <Unnamed>
2594678 | 00 | mvt lbk1 | <Unnamed>
2641035 | 00 | mvr 5 | <Unnamed>
2725661 | 00 | mvt lbk1 | <Unnamed>

# IfcBuildingElementProxy: NLRS_57_DA_LB_VAV CAV_Trox_VFC LVC RN:VFC (64)
Type - Classification: 57.00 (Uniformat); Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Trox
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: VFC; sets with these values: 2
Name (NLRS_57_DA_LB_VAV CAV_Trox_VFC LVC RN:VFC:...) | In | Diameter (mm) | Group
2146562 | 00 | 95 | mvr 5
2146634 | 00 | 95 | mvr 5
2150394 | 00 | 120 | mvr 5
2150714 | 00 | 120 | mvr 5
2150783 | 00 | 155 | mvr 5
2150943 | 00 | 155 | mvr 5
2151049 | 00 | 155 | mvr 5
2151153 | 00 | 155 | mvr 5
2151474 | 00 | 155 | mvr 5
2151964 | 00 | 155 | mvr 5
2152032 | 00 | 155 | mvr 5
2180447 | 01 | 95 | mvr 5
2180547 | 01 | 95 | mvr 5
2185691 | 01 | 195 | mvr 5
2191247 | 01 | 245 | mvt lbk1
2191353 | 01 | 245 | mvt lbk1
2191491 | 01 | 245 | mvt lbk1
2194021 | 01 | 120 | mvr 5
2203487 | 01 | 95 | mvr 5
2203501 | 01 | 95 | mvr 5
2203515 | 01 | 95 | mvr 5
2203529 | 01 | 95 | mvr 5
2203647 | 01 | 95 | mvr 5
2203775 | 01 | 95 | mvr 5
2203840 | 01 | 95 | mvr 5
2203899 | 01 | 95 | mvr 5
2204027 | 01 | 95 | mvr 5
2204041 | 01 | 95 | mvr 5
2204078 | 01 | 95 | mvr 5
2204237 | 01 | 120 | mvr 5
2204334 | 01 | 120 | mvr 5
2204392 | 01 | 120 | mvr 5
2206520 | 01 | 155 | mvr 5
2213129 | 01 | 95 | mvr 5
2214018 | 01 | 195 | mvr 5
2214136 | 01 | 195 | mvr 5
2217052 | 00 | 95 | mvr 5
2217127 | 00 | 120 | mvr 5
2217161 | 00 | 120 | mvr 5
2217233 | 00 | 120 | mvr 5
2318483 | 00 | 195 | mvr 5
2325440 | 00 | 95 | mvr 5
2436341 | 01 | 195 | mvt 2
2436373 | 01 | 195 | mvt 2
2477087 | 01 | 120 | mvr 5
2477172 | 01 | 120 | mvr 5
2481390 | 01 | 155 | mvr 5
2576627 | 00 | 155 | mvr 5
2576665 | 00 | 155 | mvr 5
2577106 | 00 | 155 | mvr 5
2577164 | 00 | 155 | mvr 5
2577206 | 00 | 155 | mvr 5
2590618 | 00 | 155 | mvr 5
2590966 | 00 | 120 | mvr 5
2602578 | 01 | 95 | mvr 5
2611170 | 00 | 120 | mvt lbk1
2611202 | 00 | 120 | mvt lbk1
2612068 | 00 | 120 | mvt lbk1
2612082 | 00 | 120 | mvt lbk1
2613160 | 00 | 120 | mvr 5
2617709 | 01 | 120 | mvt 2
2639172 | 01 | 95 | mvr 5
2639481 | 01 | 95 | mvr 5
2766324 | 01 | 120 | mvr 5

# IfcBuildingElementProxy: NLRS_57_DA_LB_VAV CAV_Trox_VFC LVC:LVC (90)
Type - Classification: 57.00 (Uniformat); Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Trox
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: LVC; sets with these values: 2
Name (NLRS_57_DA_LB_VAV CAV_Trox_VFC LVC:LVC:...) | In | Diameter (mm) | Group
2061517 | 00 | 310 | mvr 5
2069266 | 00 | 310 | mvt lbk1
2073922 | 00 | 245 | mvt lbk1
2077950 | 00 | 120 | mvt lbk1
2112376 | 00 | 310 | mvt lbk1
2156744 | 00 | 310 | mvt lbk1
2160472 | 00 | 310 | mvr 5
2182984 | 01 | 245 | mvr 5
2184156 | 01 | 245 | mvr 5
2190232 | 01 | 310 | mvr 5
2193070 | 01 | 310 | mvt lbk1
2193510 | 01 | 310 | mvr 5
2194561 | 01 | 245 | mvr 5
2194991 | 01 | 245 | mvt lbk1
2195204 | 01 | 310 | mvt lbk1
2198005 | 01 | 310 | mvt lbk1
2198329 | 01 | 310 | mvr 5
2198775 | 01 | 310 | mvr 5
2200461 | 01 | 195 | mvr 5
2200809 | 01 | 195 | mvr 5
2202327 | 01 | 195 | mvt lbk1
2202959 | 01 | 310 | mvt lbk1
2203333 | 01 | 245 | mvr 5
2205563 | 01 | 195 | mvt lbk1
2205852 | 01 | 155 | mvr 5
2206676 | 01 | 310 | mvt lbk1
2206818 | 01 | 310 | mvr 5
2214638 | 01 | 310 | mvr 5
2215342 | 00 | 310 | mvt lbk1
2215487 | 00 | 310 | mvt lbk1
2215790 | 00 | 310 | mvt lbk1
2216869 | 00 | 310 | mvr 5
2223299 | 00 | 395 | mvt lbk1
2226446 | 00 | 310 | mvr 5
2229613 | 00 | 310 | mvt lbk1
2230430 | 00 | 395 | mvr 5
2232288 | 00 | 310 | mvr 5
2306534 | 00 | 245 | mvt lbk1
2308928 | 00 | 155 | mvr 5
2311982 | 00 | 245 | mvt lbk1
2313439 | 00 | 120 | mvr 5
2314724 | 01 | 195 | mvt lbk1
2316115 | 00 | 195 | mvr 5
2317674 | 00 | 245 | mvr 5
2319586 | 00 | 155 | mvr 5
2319860 | 00 | 155 | mvr 5
2320147 | 00 | 155 | mvr 5
2320150 | 00 | 155 | mvr 5
2321733 | 00 | 195 | mvt lbk1
2321822 | 00 | 155 | mvt lbk1
2322093 | 00 | 155 | mvt lbk1
2323169 | 00 | 245 | mvt lbk1
2323488 | 00 | 195 | mvt lbk1
2323491 | 00 | 155 | mvt lbk1
2323520 | 00 | 245 | mvt lbk1
2326248 | 00 | 195 | mvr 5
2327100 | 00 | 245 | mvr 5
2328910 | 00 | 245 | mvt lbk1
2333608 | 00 | 310 | mvt lbk1
2333679 | 00 | 310 | mvt lbk1
2334506 | 00 | 155 | mvt lbk1
2337823 | 00 | 310 | mvr 5
2337882 | 00 | 310 | mvr 5
2436260 | 01 | 245 | mvt 2
2436306 | 01 | 310 | mvt 2
2436376 | 01 | 310 | mvt 2
2472187 | 00 | 310 | mvt lbk1
2490623 | 01 | 120 | mvt 2
2498335 | 01 | 350 | mvt 2
2526036 | 00 | 310 | mvr 5
2526665 | 00 | 310 | mvr 5
2564091 | 02 | 310 | mvt lbk1
2575876 | 00 | 155 | mvr 5
2577816 | 00 | 155 | mvr 5
2581638 | 00 | 120 | mvr 5
2582902 | 00 | 120 | mvt lbk1
2582928 | 00 | 120 | mvt lbk1
2584321 | 00 | 120 | mvr 5
2585199 | 00 | 245 | mvr 5
2594806 | 00 | 155 | mvt lbk1
2607096 | 02 | 310 | mvr 5
2616898 | 01 | 245 | mvt 2
2624244 | 01 | 310 | mvr 5
2624337 | 01 | 310 | mvr 5
2640665 | 00 | 195 | mvr 5
2725289 | 00 | 195 | mvt lbk1
2774052 | 00 | 245 | mvr 5
2880301 | 00 | 195 | mvr 5
2921362 | 01 | 310 | mvt lbk1
2921451 | 01 | 310 | mvt lbk1

# IfcBuildingElementProxy: NLRS_57_DA_LB_VAV_Trox_TVJ:NLRS_57_DA_LB_CAV_Trox_TVJ, NLRS_57_DA_LB_VAV_Trox_TVJ:NLRS_57_DA_LB_CAV_Trox_TVJ:2491222
In: 01
Type - Classification: 57.00 (Uniformat); Material: <Unnamed> (3)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Trox
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: NLRS_57_DA_LB_CAV_Trox_TVJ; sets with these values: 2
Pset_ProvisionForVoid - Width: 260 mm; Height: 510 mm; Depth: 260 mm
Group: mvr 5

# IfcBuildingElementProxy: NLRS_57_DA_LB_VAV_Trox_TVJ:std (4)
In: 01
Type - Classification: 57.00 (Uniformat); Material: <Unnamed> (3)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Trox
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: std; sets with these values: 2
Name (NLRS_57_DA_LB_VAV_Trox_TVJ:std:...) | Width (mm) = Depth (mm) | Height (mm) | Group
2190924 | 310 | 560 | mvt lbk1
2489848 | 310 | 460 | mvt 2
2629281 | 410 | 460 | mvr 5
2677517 | 310 | 960 | mvr 5

# IfcBuildingElementProxy: NLRS_57_DA_Rechte brandklep_generiek:NLRS_57_DA_Rechte brandklep_generiek (3)
In: 01
Type - Material: <Unnamed> (4)
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: NLRS_57_DA_Rechte brandklep_generiek; sets with these values: 2
Pset_ProvisionForVoid - Height: 115 mm
Name (NLRS_57_DA_Rechte brandklep_generiek:NLRS_57_DA_Rechte brandklep_generiek:...) | Width (mm) = Depth (mm) | Group
2598548 | 400 | mvt lbk1
2599090 | 150 | mvt lbk1
2768353 | 200 | mvr 5

# IfcBuildingElementProxy: NLRS_57_ME_LB_Dakkap_Smitsair_DK-2:DK-2, NLRS_57_ME_LB_Dakkap_Smitsair_DK-2:DK-2:1880002
In: 02
Type - Classification: 57.00 (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_BuildingElementProxyCommon - Reference: DK-2; sets with these values: 2
Group: mvaf 2

# IfcBuildingElementProxy: NLRS_74_ME_UN_close-in boiler:NLRS_74_ME_UN_close-in boiler (6)
Type - Classification: 50.00 (Uniformat); Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_BuildingElementProxyCommon - Reference: NLRS_74_ME_UN_close-in boiler; sets with these values: 2
Name (NLRS_74_ME_UN_close-in boiler:NLRS_74_ME_UN_close-in boiler:...) | In | Group
2508060 | 00 | ww 2 | Pset_ProvisionForVoid - Width: 452 mm; Height: 285 mm; Depth: 452 mm
2511362 | 00 | ww 1
2512783 | 00 | ww 3
2515712 | 00 | ww 5; kw 3
2572732 | 01 | ww 12; kw 3
2785863 | 01 | ww 4; kw 3

# IfcBuildingElementProxy: NLRS_74_PF_DE MELKER COMPACT:NLRS_74_PF_DE MELKER COMPACT 6 (2)
In: 01
Type - Material: <Unnamed> (16)
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Pset_BuildingElementProxyCommon - Reference: NLRS_74_PF_DE MELKER COMPACT 6; sets with these values: 2
Name (NLRS_74_PF_DE MELKER COMPACT:NLRS_74_PF_DE MELKER COMPACT 6:...) | Group
2776543 | ww 14; ww 17; ww 15; ww 18; ww 16; ww 13; ww 10; kw 3 | Pset_ProvisionForVoid - Width: 30 mm; Height: 315.267 mm; Depth: 30 mm
2778282 | ww 31; ww 26; ww 27; ww 29; ww 30; ww 28; ww 10; kw 3 | Material: <Unnamed>

# IfcCovering: Duct Insulation:Isolatiemateriaal (989)
PredefinedType: INSULATION; Classification: 3A(57) (Uniformat)
Pset_CoveringCommon - Reference: Isolatiemateriaal; sets with these values: 2
Pset_ProductRequirements - Category: Duct Insulations
Name (Duct Insulation:Isolatiemateriaal:...) | In
2746731 | 01
2746732 | 01
2746733 | 01
2746734 | 02
2746735 | 01
2746736 | 01
2746737 | 01
2746738 | 01
2746739 | 01
2746740 | 01
2746741 | 01
2746742 | 01
2746743 | 01
2746744 | 01
2746745 | 01
2746746 | 01
2746747 | 01
2746748 | 01
2746749 | 01
2746750 | 01
2746751 | 01
2746752 | 01
2746753 | 01
2746754 | 01
2746755 | 01
2746756 | 01
2746757 | 01
2746758 | 01
2746759 | 01
2746760 | 01
2746761 | 01
2746762 | 01
2746763 | 01
2746764 | 01
2746765 | 01
2746766 | 01
2746767 | 01
2746768 | 01
2746769 | 01
2746770 | 01
2746771 | 01
2746772 | 01
2746773 | 01
2746774 | 01
2746775 | 01
2746776 | 01
2746777 | 01
2746778 | 01
2746779 | 01
2746780 | 01
2746781 | 01
2746782 | 01
2746783 | 01
2746784 | 01
2746785 | 01
2746786 | 01
2746787 | 01
2746788 | 01
2746789 | 01
2746790 | 01
2746791 | 01
2746792 | 01
2746793 | 01
2746794 | 01
2746795 | 01
2746796 | 01
2746797 | 01
2746798 | 01
2746799 | 01
2746800 | 01
2746801 | 01
2746802 | 01
2746803 | 01
2746804 | 01
2746805 | 01
2746806 | 01
2746807 | 01
2746808 | 01
2746809 | 01
2746810 | 01
2746811 | 01
2746812 | 01
2746813 | 01
2746814 | 01
2746815 | 01
2746816 | 01
2746817 | 01
2746818 | 01
2746819 | 01
2746820 | 01
2746821 | 01
2746822 | 01
2746823 | 01
2746824 | 01
2746825 | 01
2746826 | 01
2746827 | 01
2746828 | 01
2746829 | 01
2746830 | 01
2746831 | 01
2746832 | 01
2746833 | 01
2746834 | 01
2746835 | 01
2746836 | 01
2746837 | 01
2746838 | 01
2746839 | 01
2746840 | 01
2746841 | 01
2746842 | 01
2746843 | 01
2746844 | 01
2746845 | 01
2746846 | 01
2746847 | 01
2746848 | 01
2746849 | 01
2746850 | 01
2746851 | 01
2746852 | 01
2746853 | 01
2746854 | 01
2746855 | 01
2746856 | 01
2746857 | 01
2746858 | 01
2746859 | 01
2746860 | 01
2746861 | 01
2746862 | 01
2746863 | 01
2746864 | 01
2746865 | 01
2746866 | 01
2746867 | 01
2746868 | 01
2746869 | 01
2746870 | 01
2746871 | 01
2746872 | 01
2746873 | 01
2746874 | 01
2746875 | 02
2746876 | 02
2746877 | 02
2746878 | 02
2746879 | 02
2746880 | 02
2746881 | 02
2746918 | 01
2746919 | 01
2746920 | 00
2746921 | 00
2746922 | 00
2746923 | 00
2746924 | 00
2746925 | 00
2746926 | 00
2746927 | 00
2746928 | 00
2746929 | 00
2746930 | 00
2746931 | 00
2746932 | 00
2746933 | 00
2746934 | 00
2746935 | 00
2746936 | 00
2746937 | 00
2746938 | 00
2746939 | 01
2746940 | 00
2746941 | 00
2746942 | 00
2746943 | 00
2746944 | 00
2746945 | 00
2746946 | 00
2746947 | 00
2746948 | 00
2746949 | 00
2746950 | 00
2746951 | 00
2746952 | 00
2746953 | 00
2746954 | 00
2746955 | 00
2746956 | 00
2746957 | 00
2746958 | 00
2746959 | 00
2746960 | 00
2746961 | 00
2746962 | 00
2746963 | 00
2746964 | 00
2746965 | 00
2746966 | 00
2746967 | 00
2746968 | 00
2746969 | 00
2746970 | 00
2746971 | 00
2746972 | 00
2746973 | 00
2746974 | 00
2746975 | 00
2746976 | 00
2746977 | 00
2746978 | 00
2746979 | 00
2746980 | 00
2746981 | 00
2746982 | 00
2746983 | 00
2746984 | 00
2746985 | 00
2746986 | 00
2746987 | 00
2746988 | 00
2746989 | 00
2746990 | 00
2746991 | 01
2746992 | 01
2746993 | 02
2746994 | 01
2746995 | 02
2746996 | 01
2746997 | 01
2746998 | 01
2746999 | 01
2747000 | 02
2747001 | 02
2747002 | 00
2747003 | 00
2747004 | 00
2747005 | 01
2747006 | 01
2747007 | 01
2747008 | 01
2747009 | 01
2747010 | 01
2747011 | 01
2747012 | 01
2747013 | 01
2747014 | 01
2747015 | 00
2747016 | 01
2747017 | 00
2747018 | 00
2747019 | 00
2747020 | 00
2747021 | 00
2747022 | 00
2747023 | 00
2747024 | 00
2747025 | 00
2747026 | 00
2747027 | 00
2747028 | 00
2747029 | 00
2747030 | 00
2747031 | 00
2747032 | 00
2747033 | 00
2747034 | 00
2747035 | 00
2747036 | 00
2747037 | 00
2747038 | 00
2747039 | 00
2747040 | 01
2747041 | 01
2747042 | 01
2747043 | 01
2747044 | 01
2747045 | 01
2747046 | 01
2747051 | 00
2747052 | 00
2747053 | 00
2747054 | 00
2747055 | 00
2747056 | 00
2747057 | 00
2747058 | 00
2747059 | 01
2747060 | 01
2747061 | 01
2747062 | 01
2747063 | 01
2747064 | 01
2747065 | 01
2747066 | 01
2747067 | 01
2747068 | 01
2747069 | 01
2747070 | 01
2747071 | 01
2747072 | 01
2747073 | 01
2747074 | 01
2747075 | 01
2747076 | 01
2747077 | 01
2747078 | 01
2747079 | 01
2747080 | 01
2747081 | 01
2747082 | 01
2747083 | 01
2747084 | 01
2747085 | 01
2747086 | 01
2747087 | 01
2747088 | 01
2747089 | 01
2747090 | 01
2747091 | 01
2747092 | 01
2747093 | 01
2747094 | 01
2747095 | 01
2747096 | 01
2747097 | 01
2747098 | 01
2747099 | 01
2747100 | 01
2747101 | 01
2747102 | 01
2747103 | 01
2747104 | 01
2747105 | 01
2747106 | 01
2747107 | 01
2747108 | 01
2747109 | 01
2747110 | 01
2747111 | 01
2747112 | 01
2747113 | 01
2747114 | 01
2747115 | 01
2747116 | 01
2747117 | 01
2747118 | 01
2747119 | 01
2747120 | 01
2747121 | 01
2747122 | 01
2747123 | 01
2747124 | 01
2747125 | 01
2747126 | 01
2747127 | 01
2747128 | 01
2747129 | 01
2747130 | 01
2747131 | 01
2747132 | 01
2747133 | 01
2747134 | 01
2747135 | 01
2747136 | 01
2747137 | 01
2747138 | 01
2747139 | 01
2747140 | 01
2747141 | 01
2747142 | 01
2747143 | 01
2747144 | 01
2747145 | 01
2747146 | 01
2747147 | 00
2747148 | 00
2747149 | 00
2747150 | 00
2747151 | 00
2747152 | 00
2747153 | 00
2747154 | 00
2747155 | 00
2747156 | 00
2747157 | 00
2747158 | 00
2747159 | 00
2747160 | 00
2747161 | 00
2747162 | 00
2747163 | 00
2747164 | 00
2747165 | 00
2747166 | 00
2747167 | 00
2747168 | 00
2747169 | 00
2747170 | 00
2747171 | 00
2747172 | 00
2747173 | 00
2747174 | 00
2747175 | 00
2747176 | 00
2747177 | 00
2747178 | 00
2747179 | 00
2747180 | 00
2747181 | 00
2747182 | 00
2747183 | 00
2747184 | 00
2747185 | 00
2747186 | 00
2747187 | 00
2747188 | 00
2747189 | 00
2747190 | 00
2747191 | 00
2747192 | 00
2747193 | 00
2747194 | 00
2747195 | 00
2747196 | 00
2747197 | 00
2747198 | 00
2747199 | 00
2747200 | 00
2747201 | 00
2747202 | 00
2747203 | 00
2747204 | 00
2747205 | 00
2747206 | 00
2747207 | 00
2747208 | 00
2747209 | 00
2747210 | 00
2747211 | 00
2747212 | 00
2747213 | 00
2747214 | 00
2747215 | 00
2747216 | 00
2747217 | 00
2747218 | 00
2747219 | 00
2747220 | 00
2747221 | 00
2747222 | 00
2747223 | 00
2747224 | 00
2747225 | 00
2747226 | 00
2747227 | 00
2747228 | 00
2747229 | 00
2747230 | 00
2747231 | 00
2747232 | 00
2747233 | 00
2747234 | 00
2747235 | 00
2747236 | 00
2747237 | 00
2747238 | 00
2747239 | 00
2747240 | 00
2747241 | 00
2747242 | 00
2747243 | 00
2747244 | 00
2747245 | 00
2747246 | 00
2747247 | 00
2747248 | 00
2747249 | 00
2747250 | 00
2747251 | 00
2747252 | 00
2747253 | 00
2747254 | 00
2747255 | 00
2747256 | 00
2747257 | 00
2747258 | 00
2747259 | 00
2747260 | 00
2747261 | 00
2747262 | 00
2747263 | 00
2747264 | 00
2747265 | 00
2747266 | 00
2747267 | 00
2747268 | 00
2747269 | 00
2747270 | 00
2747271 | 00
2747272 | 00
2747273 | 00
2747274 | 00
2747275 | 01
2747276 | 01
2747277 | 01
2747278 | 01
2747279 | 01
2747280 | 01
2747281 | 01
2747282 | 01
2747283 | 01
2747284 | 01
2747285 | 01
2747286 | 01
2747287 | 01
2747288 | 01
2747289 | 01
2747290 | 01
2747291 | 01
2747292 | 01
2747293 | 01
2747294 | 01
2747295 | 01
2747296 | 01
2747297 | 01
2747298 | 01
2747299 | 01
2747300 | 01
2747301 | 01
2747302 | 01
2747303 | 01
2747304 | 01
2747305 | 01
2747306 | 01
2747307 | 01
2747308 | 01
2747309 | 01
2747310 | 01
2747311 | 01
2747312 | 01
2747313 | 01
2747314 | 01
2747315 | 01
2747316 | 01
2747317 | 01
2747318 | 01
2747319 | 01
2747320 | 01
2747321 | 01
2747322 | 01
2747323 | 01
2747324 | 01
2747325 | 01
2747326 | 01
2747327 | 01
2747328 | 01
2747329 | 01
2747330 | 01
2747331 | 01
2747332 | 01
2747333 | 01
2747334 | 01
2747335 | 01
2747336 | 01
2747337 | 01
2747338 | 00
2747339 | 00
2747340 | 00
2747341 | 00
2747342 | 00
2747343 | 00
2747344 | 00
2747345 | 00
2747346 | 00
2747347 | 00
2747348 | 00
2747349 | 00
2747350 | 00
2747351 | 00
2747352 | 00
2747353 | 00
2747354 | 00
2747355 | 00
2747356 | 00
2747357 | 00
2747358 | 00
2747359 | 00
2747360 | 00
2747361 | 00
2747362 | 00
2747363 | 00
2747364 | 00
2747365 | 00
2747366 | 00
2747367 | 00
2747368 | 00
2747369 | 00
2747370 | 00
2747371 | 00
2747372 | 00
2747373 | 00
2747374 | 00
2747375 | 00
2747376 | 00
2747377 | 00
2747378 | 00
2747379 | 00
2747380 | 00
2747381 | 00
2747382 | 00
2747383 | 00
2747384 | 00
2747385 | 00
2747386 | 00
2747387 | 00
2747388 | 00
2747389 | 00
2747390 | 00
2747391 | 00
2747392 | 00
2747393 | 00
2747394 | 00
2747395 | 00
2747396 | 00
2747397 | 00
2747398 | 00
2747399 | 00
2747400 | 00
2747401 | 00
2747402 | 01
2747403 | 01
2747404 | 01
2747405 | 01
2747406 | 01
2747407 | 01
2747408 | 01
2747409 | 00
2747410 | 00
2747411 | 00
2747412 | 00
2747413 | 00
2747414 | 00
2747415 | 00
2747416 | 00
2747417 | 00
2747418 | 00
2747419 | 00
2747420 | 00
2747421 | 00
2747422 | 00
2747423 | 00
2747424 | 00
2747425 | 00
2747426 | 00
2747427 | 01
2747428 | 01
2747429 | 01
2747430 | 01
2747431 | 01
2747432 | 01
2747433 | 01
2747434 | 01
2747435 | 01
2747436 | 00
2747437 | 00
2747438 | 00
2747439 | 00
2747440 | 00
2747441 | 00
2747442 | 00
2747443 | 00
2747444 | 00
2747445 | 00
2747446 | 00
2747447 | 00
2747448 | 00
2747449 | 00
2747450 | 00
2747451 | 00
2747452 | 00
2747453 | 00
2747454 | 00
2747455 | 00
2747456 | 00
2747457 | 00
2747458 | 00
2747459 | 00
2747460 | 00
2747461 | 00
2747462 | 00
2747463 | 00
2747464 | 00
2747465 | 00
2747466 | 00
2747467 | 00
2747468 | 00
2747469 | 00
2747470 | 00
2747471 | 00
2747472 | 00
2747473 | 00
2747474 | 00
2747475 | 00
2747476 | 00
2747477 | 00
2747478 | 00
2747479 | 00
2747480 | 00
2747481 | 00
2747482 | 00
2747483 | 00
2747484 | 00
2747485 | 00
2747486 | 00
2747487 | 00
2747488 | 00
2747489 | 00
2747490 | 00
2747491 | 00
2747492 | 00
2747493 | 00
2747494 | 00
2747495 | 00
2747496 | 00
2747497 | 00
2747498 | 00
2747499 | 00
2747500 | 00
2747501 | 00
2747502 | 00
2747503 | 00
2747504 | 00
2747505 | 00
2747506 | 00
2747507 | 00
2747508 | 00
2747509 | 00
2747510 | 00
2747511 | 00
2747512 | 00
2747513 | 00
2747514 | 00
2747515 | 00
2747516 | 00
2747517 | 00
2747518 | 00
2747519 | 00
2747520 | 00
2747521 | 00
2747522 | 00
2747523 | 00
2747524 | 00
2747525 | 00
2747526 | 00
2747527 | 00
2747528 | 00
2747529 | 00
2747530 | 00
2747531 | 00
2747532 | 00
2747533 | 00
2747534 | 00
2747535 | 00
2747536 | 00
2747537 | 00
2747538 | 00
2747539 | 00
2747540 | 00
2747541 | 00
2747542 | 00
2747543 | 00
2747544 | 00
2747545 | 00
2747546 | 00
2747547 | 01
2747548 | 00
2747549 | 01
2747550 | 00
2747551 | 01
2747552 | 02
2747553 | 02
2747554 | 01
2747555 | 01
2747556 | 01
2747557 | 01
2747558 | 01
2747559 | 00
2747560 | 00
2747561 | 00
2747562 | 00
2747563 | 00
2747564 | 00
2747565 | 00
2747566 | 00
2747567 | 00
2747568 | 00
2747569 | 00
2747571 | 01
2747572 | 01
2747573 | 02
2747574 | 01
2747575 | 01
2747586 | 00
2747587 | 00
2747588 | 02
2747589 | 02
2747590 | 02
2747591 | 02
2747592 | 02
2747593 | 02
2747594 | 02
2747595 | 02
2747596 | 02
2747597 | 02
2747598 | 02
2747599 | 02
2747600 | 02
2747601 | 02
2747602 | 02
2747603 | 02
2747604 | 02
2747605 | 02
2747606 | 02
2747607 | 02
2747608 | 02
2747609 | 00
2747610 | 00
2747611 | 00
2747612 | 00
2747613 | 00
2747614 | 00
2747615 | 00
2747616 | 00
2747617 | 00
2747618 | 00
2747619 | 00
2747620 | 00
2747621 | 00
2747622 | 00
2747623 | 00
2747624 | 00
2747625 | 00
2747626 | 00
2747627 | 00
2747628 | 00
2747629 | 00
2747630 | 00
2747631 | 00
2747632 | 01
2747633 | 00
2747634 | 00
2747635 | 00
2747636 | 00
2747637 | 01
2747638 | 01
2747639 | 00
2747640 | 00
2747641 | 00
2747642 | 00
2747643 | 00
2747644 | 00
2747645 | 00
2747646 | 00
2747647 | 00
2747648 | 00
2747649 | 00
2747650 | 00
2747651 | 00
2747652 | 00
2747653 | 00
2747654 | 00
2747655 | 01
2747656 | 01
2747657 | 01
2747658 | 01
2747659 | 01
2747660 | 01
2747661 | 01
2747662 | 01
2747663 | 01
2747664 | 01
2747665 | 01
2747666 | 01
2747667 | 01
2747668 | 01
2747669 | 02
2747670 | 02
2747671 | 00
2747672 | 00
2747673 | 00
2747674 | 00
2747675 | 00
2747676 | 00
2747677 | 00
2747678 | 00
2747679 | 00
2747680 | 00
2747681 | 00
2747682 | 00
2747683 | 00
2747684 | 00
2747685 | 00
2747686 | 00
2747687 | 00
2747688 | 00
2747689 | 00
2747690 | 00
2747691 | 00
2747692 | 00
2747693 | 00
2747694 | 00
2747695 | 00
2747696 | 00
2747697 | 00
2747698 | 00
2747699 | 00
2747700 | 00
2747705 | 00
2747706 | 01
2747707 | 02
2747708 | 02
2747709 | 02
2747710 | 00
2747711 | 00
2747712 | 00
2747713 | 00
2747714 | 00
2747715 | 00
2747716 | 00
2747717 | 00
2747718 | 00
2747719 | 00
2747720 | 00
2747721 | 00
2747722 | 00
2747723 | 00
2747724 | 00
2747725 | 00
2747726 | 00
2747727 | 00
2747728 | 00
2747729 | 00
2747730 | 00
2747731 | 00
2747732 | 00
2747733 | 00
2747734 | 00
2747735 | 00
2747736 | 00
2747737 | 00
2747738 | 00
2747739 | 00
2747746 | 01
2747747 | 02
2747748 | 02
2747749 | 02
2747750 | 02
2747751 | 02
2747752 | 02
2747753 | 02
2747754 | 02
2747755 | 02
2747756 | 02
2747757 | 02
2747766 | 01
2747767 | 01
2747768 | 01
2747769 | 01
2747770 | 01
2747771 | 01
2747772 | 01
2747773 | 02
2748068 | 00
2919963 | 01
2919971 | 01
2920768 | 01
2920772 | 01
2920777 | 01
2920781 | 01
2921017 | 01
2921021 | 01
2921024 | 01
2921027 | 01
2921478 | 01
2921479 | 01
2921573 | 01
2921576 | 01

# IfcCovering: Duct Insulation:Isolatiemateriaal Brandwerend (86)
PredefinedType: INSULATION; Classification: 3A(57) (Uniformat)
Pset_CoveringCommon - Reference: Isolatiemateriaal Brandwerend; sets with these values: 2
Pset_ProductRequirements - Category: Duct Insulations
Name (Duct Insulation:Isolatiemateriaal Brandwerend:...) | In
2586118 | 00
2586119 | 00
2586120 | 00
2586121 | 00
2586122 | 00
2586123 | 00
2586124 | 00
2586125 | 00
2586126 | 00
2586127 | 00
2586128 | 00
2586237 | 00
2588930 | 00
2588931 | 00
2588932 | 00
2588933 | 00
2588934 | 00
2589128 | 00
2589129 | 00
2589130 | 00
2589131 | 00
2589132 | 00
2589133 | 00
2589134 | 00
2589135 | 00
2589136 | 00
2589137 | 00
2592120 | 00
2592121 | 00
2592139 | 00
2592544 | 00
2592545 | 00
2592546 | 00
2592732 | 00
2592733 | 00
2592734 | 00
2596960 | 01
2596961 | 01
2596962 | 01
2596963 | 01
2596964 | 01
2596965 | 01
2596967 | 01
2596968 | 01
2596969 | 01
2596970 | 01
2597865 | 01
2598240 | 01
2598241 | 01
2598242 | 01
2598243 | 01
2598244 | 01
2598245 | 01
2598246 | 01
2598247 | 01
2598248 | 01
2598249 | 01
2599167 | 01
2599168 | 01
2599169 | 01
2599170 | 01
2599171 | 01
2599559 | 01
2603448 | 01
2603449 | 01
2603450 | 01
2603451 | 01
2603452 | 01
2603453 | 01
2603454 | 01
2603455 | 01
2603456 | 01
2603457 | 01
2603458 | 01
2603459 | 01
2603460 | 01
2629242 | 01
2629243 | 01
2629244 | 01
2748338 | 00
2748339 | 00
2748340 | 00
2748341 | 00
2748342 | 00
2768365 | 01
2920782 | 01

# IfcDistributionPort (14877)
Description: Flow
Name | FlowDirection | Group
InPort_1104700 | SINK | mvr 5
OutPort_1105265 | SOURCE | mvr 5
InPort_2683447 | SINK | mvr 5
OutPort_1104700 | SOURCE | mvr 5
InPort_1105265 | SINK | mvr 5
OutPort_1820800 | SOURCE | mvr 5
InPort_1953879 | SINK | mvr 5
OutPort_1146354 | SOURCE | mvr 5
InPort_1146386 | SINK | mvt lbk1
OutPort_1726210 | SOURCE | mvt lbk1
InPort_1146387 | SINK | mvt lbk1
OutPort_1726212 | SOURCE | mvt lbk1
InPort_1146698 | SINK | mvt lbk1
OutPort_1914032 | SOURCE | mvt lbk1
InPort_1146699 | SINK | mvt lbk1
OutPort_1914034 | SOURCE | mvt lbk1
InPort_2017624 | SINK | mvr 5
OutPort_1146710 | SOURCE | mvr 5
InPort_2213164 | SINK | mvr 5
OutPort_1153867 | SOURCE | mvr 5
InPort_1154415 | SINK | mvt lbk1
OutPort_2204982 | SOURCE | mvt lbk1
InPort_1154451 | SINK | mvt lbk1
OutPort_2314560 | SOURCE | mvt lbk1
InPort_1154510 | SINK | mvt lbk1
OutPort_2202076 | SOURCE | mvt lbk1
InPort_2017622 | SINK | mvr 5
OutPort_1154548 | SOURCE | mvr 5
InPort_2037496 | SINK | mvr 5
OutPort_1154973 | SOURCE | mvr 5
InPort_2481627 | SINK | mvr 5
OutPort_1154976 | SOURCE | mvr 5
InPort_2037022 | SINK | mvr 5
OutPort_1155265 | SOURCE | mvr 5
InPort_1159598 | SINK | mvt lbk1
OutPort_2016629 | SOURCE | mvt lbk1
InPort_1159599 | SINK | mvt lbk1
OutPort_2016631 | SOURCE | mvt lbk1
InPort_1159659 | SINK | mvt lbk1
OutPort_2009475 | SOURCE | mvt lbk1
InPort_1159660 | SINK | mvt lbk1
OutPort_2009473 | SOURCE | mvt lbk1
InPort_1160456 | SINK | mvt lbk1
OutPort_2015218 | SOURCE | mvt lbk1
InPort_2026655 | SINK | mvr 5
OutPort_1160457 | SOURCE | mvr 5
InPort_2194107 | SINK | mvr 5
OutPort_1164516 | SOURCE | mvr 5
InPort_1246538 | SINK | gkwr 1
OutPort_1281796 | SOURCE | gkwr 1
2 x InPort_1246538 | SINK | gkwr 4
OutPort_1265653 | SOURCE | gkwr 4
OutPort_1265426 | SOURCE | gkwr 4
InPort_1282516 | SINK | gkwa 2
OutPort_1246538 | SOURCE | gkwa 2
InPort_1265967 | SINK | brr 1
OutPort_1246547 | SOURCE | brr 1
InPort_1246636 | SINK | gkwa 2
OutPort_1246632 | SOURCE | gkwa 2
InPort_1246632 | SINK | gkwa 2
OutPort_1246634 | SOURCE | gkwa 2
Port_1246634 | SOURCE | gkwa 2
2 x InPort_1251485 | SOURCEANDSINK | brr 1
OutPort_1265664 | SOURCEANDSINK | brr 1
OutPort_1268573 | SOURCEANDSINK | brr 1
2 x InPort_1252645 | SOURCEANDSINK | brr 1
OutPort_1265787 | SOURCEANDSINK | brr 1
OutPort_1265112 | SOURCEANDSINK | brr 1
2 x InPort_1254937 | SOURCEANDSINK | brr 1
OutPort_1262541 | SOURCEANDSINK | brr 1
2 x OutPort_1259675 | SOURCEANDSINK | brr 1
2 x InPort_1254956 | SOURCEANDSINK | brr 1
OutPort_1254999 | SOURCEANDSINK | brr 1
2 x OutPort_2743690 | SOURCEANDSINK | brr 1
InPort_1254999 | SOURCEANDSINK | brr 1
OutPort_1259673 | SOURCEANDSINK | brr 1
InPort_1259833 | SINK | brr 1
OutPort_1257197 | SOURCE | brr 1
InPort_1259809 | SINK | brr 1
OutPort_1259249 | SOURCE | brr 1
InPort_1259673 | SOURCEANDSINK | brr 1
Port_1259673 | SOURCEANDSINK | brr 1
InPort_1259838 | SINK | brr 1
OutPort_1259809 | SOURCE | brr 1
InPort_1265510 | SINK | brr 1
OutPort_1259833 | SOURCE | brr 1
InPort_1265653 | SINK | brr 1
OutPort_1259838 | SOURCE | brr 1
2 x InPort_1262165 | SOURCEANDSINK | bra 3
OutPort_1263556 | SOURCEANDSINK | bra 3
OutPort_1262848 | SOURCEANDSINK | bra 3
InPort_1262541 | SOURCEANDSINK | brr 1
OutPort_1263947 | SOURCEANDSINK | brr 1
InPort_1262848 | SOURCEANDSINK | bra 3
2 x OutPort_2743490 | SOURCEANDSINK | bra 3
InPort_1263556 | SOURCEANDSINK | bra 3
2 x OutPort_2912222 | SOURCEANDSINK | bra 3
2 x InPort_1263805 | SOURCEANDSINK | bra 3
2 x OutPort_2912255 | SOURCEANDSINK | bra 3
2 x OutPort_2912181 | SOURCEANDSINK | bra 3
2 x InPort_1263947 | SOURCEANDSINK | brr 1
OutPort_1268473 | SOURCEANDSINK | brr 1
OutPort_1264990 | SOURCEANDSINK | brr 1
InPort_1264257 | SINK | brr 1
OutPort_1265965 | SOURCE | brr 1
InPort_1264886 | SINK | brr 1
OutPort_1264257 | SOURCE | brr 1
InPort_1264884 | SINK | brr 1
OutPort_1264867 | SOURCE | brr 1
InPort_1264867 | SINK | brr 1
OutPort_1264886 | SOURCE | brr 1
InPort_2743242 | SINK | brr 1
OutPort_1264880 | SOURCE | brr 1
InPort_1264880 | SINK | brr 1
OutPort_1264884 | SOURCE | brr 1
3 x InPort_1264968 | SOURCEANDSINK | brr 1
2 x OutPort_1265798 | SOURCEANDSINK | brr 1
2 x OutPort_1265002 | SOURCEANDSINK | brr 1
OutPort_2912233 | SOURCEANDSINK | brr 1
2 x InPort_1264976 | SOURCEANDSINK | brr 1
2 x OutPort_1264998 | SOURCEANDSINK | brr 1
InPort_1264990 | SOURCEANDSINK | brr 1
2 x OutPort_1264994 | SOURCEANDSINK | brr 1
2 x InPort_1264991 | SOURCEANDSINK | brr 1
InPort_1265112 | SOURCEANDSINK | brr 1
2 x OutPort_1265474 | SOURCEANDSINK | brr 1
InPort_1265426 | SOURCEANDSINK | brr 1
InPort_1265426 | SINK | brr 1
OutPort_1265510 | SOURCE | brr 1
InPort_1265653 | SOURCEANDSINK | brr 1
2 x OutPort_1265676 | SOURCEANDSINK | brr 1
InPort_1265664 | SOURCEANDSINK | brr 1
InPort_1265787 | SOURCEANDSINK | brr 1
2 x OutPort_1268416 | SOURCEANDSINK | brr 1
2 x InPort_1265796 | SOURCEANDSINK | brr 1
2 x OutPort_1268581 | SOURCEANDSINK | brr 1
InPort_1265965 | SINK | brr 1
OutPort_1265967 | SOURCE | brr 1
InPort_1270938 | SINK | cvr 3
OutPort_1266300 | SOURCE | cvr 3
InPort_1266300 | SINK | cva 3
OutPort_1270830 | SOURCE | cva 3
Port_1266300 | SOURCEANDSINK | cva 3
Port_1266300 | SINK
InPort_1266300 | SOURCEANDSINK | cvr 7 (1)
2 x OutPort_1278855 | SOURCEANDSINK | cvr 7 (1)
Port_1266300 | SOURCEANDSINK | cva 7
InPort_1266300 | SOURCEANDSINK | cva 5
2 x OutPort_1278989 | SOURCEANDSINK | cva 5
Port_1266300 | SOURCEANDSINK | cvr 3
Port_1266300 | SOURCEANDSINK | cvr 6
2 x InPort_1268408 | SOURCEANDSINK | brr 1
2 x OutPort_1268486 | SOURCEANDSINK | brr 1
InPort_1268473 | SOURCEANDSINK | brr 1
InPort_1268573 | SOURCEANDSINK | brr 1
InPort_1269268 | SINK | cva 6
OutPort_1269047 | SOURCE | cva 6
InPort_1269047 | SINK | cva 6
OutPort_2911649 | SOURCE | cva 6
InPort_1269093 | SINK | cvr 5
OutPort_2911661 | SOURCE | cvr 5
InPort_2911856 | SINK | cvr 5
OutPort_1269093 | SOURCE | cvr 5
InPort_1269099 | SINK | cvr 5
OutPort_1269137 | SOURCE | cvr 5
InPort_2911661 | SINK | cvr 5
OutPort_1269099 | SOURCE | cvr 5
InPort_1269137 | SINK | cvr 5
OutPort_1269510 | SOURCE | cvr 5
InPort_1269270 | SINK | cva 6
OutPort_1269268 | SOURCE | cva 6
InPort_1269647 | SINK | cva 6
2 x OutPort_1269270 | SOURCE | cva 6
InPort_1269579 | SINK | cva 6
InPort_1269351 | SINK | cvr 5
OutPort_1269423 | SOURCE | cvr 5
2 x InPort_1269509 | SINK | cvr 5
OutPort_1269351 | SOURCE | cvr 5
InPort_2739777 | SINK | cvr 5
OutPort_1269398 | SOURCE | cvr 5
InPort_1269398 | SINK | cvr 5
OutPort_2739666 | SOURCE | cvr 5
InPort_1269419 | SINK | cvr 5
OutPort_2739777 | SOURCE | cvr 5
InPort_1270091 | SINK | cvr 5
OutPort_1269419 | SOURCE | cvr 5
InPort_1269421 | SINK | cvr 5
OutPort_1270093 | SOURCE | cvr 5
InPort_1269423 | SINK | cvr 5
OutPort_1269421 | SOURCE | cvr 5
InPort_1269476 | SINK | cvr 5
OutPort_1269522 | SOURCE | cvr 5
InPort_1269520 | SINK | cvr 5
OutPort_1269476 | SOURCE | cvr 5
InPort_1269859 | SINK | cvr 5
OutPort_1269507 | SOURCE | cvr 5
InPort_1269507 | SINK | cvr 5
OutPort_1269520 | SOURCE | cvr 5
OutPort_1269517 | SOURCE | cvr 5
InPort_1269510 | SINK | cvr 5
OutPort_1269509 | SOURCE | cvr 5
InPort_1269517 | SINK | cvr 5
OutPort_1269861 | SOURCE | cvr 5
InPort_1269522 | SINK | cvr 5
2 x OutPort_2733843 | SOURCE | cvr 5
InPort_1269583 | SINK | cva 6
OutPort_1269547 | SOURCE | cva 6
InPort_1269547 | SINK | cva 6
OutPort_1269581 | SOURCE | cva 6
InPort_1269575 | SINK | cva 6
OutPort_1270009 | SOURCE | cva 6
InPort_1269581 | SINK | cva 6
OutPort_1269575 | SOURCE | cva 6
InPort_1270011 | SINK | cva 6
OutPort_1269577 | SOURCE | cva 6
InPort_1269577 | SINK | cva 6
OutPort_1269579 | SOURCE | cva 6
2 x InPort_2733843 | SINK | cva 6
OutPort_1269583 | SOURCE | cva 6
InPort_1269615 | SINK | cva 6
OutPort_1269650 | SOURCE | cva 6
InPort_1269652 | SINK | cva 6
OutPort_1269615 | SOURCE | cva 6
InPort_1269645 | SINK | cva 6
OutPort_1269953 | SOURCE | cva 6
InPort_1269650 | SINK | cva 6
OutPort_1269645 | SOURCE | cva 6
InPort_1269955 | SINK | cva 6
OutPort_1269647 | SOURCE | cva 6
OutPort_1269652 | SOURCE | cva 6
InPort_1269861 | SINK | cvr 5
OutPort_1269859 | SOURCE | cvr 5
InPort_1269953 | SINK | cva 6
OutPort_1269955 | SOURCE | cva 6
InPort_1270009 | SINK | cva 6
OutPort_1270011 | SOURCE | cva 6
InPort_1270093 | SINK | cvr 5
OutPort_1270091 | SOURCE | cvr 5
InPort_1270830 | SINK | cva 3
OutPort_2738983 | SOURCE | cva 3
2 x InPort_1270848 | SOURCEANDSINK | cva 5
OutPort_1278562 | SOURCEANDSINK | cva 5
OutPort_1278985 | SOURCEANDSINK | cva 5
InPort_2741036 | SINK | cvr 3
OutPort_1270938 | SOURCE | cvr 3
InPort_1271408 | SINK | cvr 3
OutPort_2741032 | SOURCE | cvr 3
InPort_2737921 | SINK | cvr 3
OutPort_1271408 | SOURCE | cvr 3
InPort_1271416 | SINK | cvr 3
OutPort_2737925 | SOURCE | cvr 3
InPort_2912998 | SINK | cvr 3
OutPort_1271416 | SOURCE | cvr 3
InPort_1271456 | SINK | cva 3
OutPort_2738250 | SOURCE | cva 3
InPort_2738983 | SINK | cva 3
OutPort_1271456 | SOURCE | cva 3
InPort_2741032 | SINK | cvr 3
OutPort_1273163 | SOURCE | cvr 3
InPort_1273163 | SINK | cvr 3
OutPort_2741036 | SOURCE | cvr 3
5 x InPort_1274075 | SINK | cvr 7 (1)
OutPort_1275366 | SOURCE | cvr 7 (1)
5 x InPort_1274075 | SOURCEANDSINK | cvr 7 (1)
2 x OutPort_1286170 | SOURCEANDSINK | cvr 7 (1)
OutPort_1277341 | SOURCEANDSINK | cvr 7 (1)
OutPort_1274077 | SOURCE | cvr 7 (1)
OutPort_1275416 | SOURCE | cvr 7 (1)
OutPort_1274426 | SOURCE | cvr 7 (1)
OutPort_1274383 | SOURCE | cvr 7 (1)
2 x OutPort_1286188 | SOURCEANDSINK | cvr 7 (1)
2 x OutPort_1286206 | SOURCEANDSINK | cvr 7 (1)
2 x OutPort_1283511 | SOURCEANDSINK | cvr 7 (1)
InPort_1280619 | SINK | gkwr 1
OutPort_1274081 | SOURCE | gkwr 1
9 x InPort_1274081 | SINK | gkwr 1
OutPort_1286197 | SOURCE | gkwr 1
OutPort_1274358 | SOURCE | gkwr 1
OutPort_1286161 | SOURCE | gkwr 1
OutPort_1274364 | SOURCE | gkwr 1
OutPort_1275291 | SOURCE | gkwr 1
OutPort_1286179 | SOURCE | gkwr 1
OutPort_1277525 | SOURCE | gkwr 1
OutPort_1274085 | SOURCE | gkwr 1
OutPort_1275383 | SOURCE | gkwr 1
InPort_1274356 | SINK | gkwr 1
OutPort_1274360 | SOURCE | gkwr 1
InPort_1274358 | SINK | gkwr 1
OutPort_1274356 | SOURCE | gkwr 1
InPort_1274364 | SINK | gkwr 1
OutPort_1274362 | SOURCE | gkwr 1
InPort_1274362 | SINK | gkwr 1
OutPort_1274368 | SOURCE | gkwr 1
InPort_1274366 | SINK | gkwr 1
OutPort_1274370 | SOURCE | gkwr 1
InPort_1274368 | SINK | gkwr 1
OutPort_1274366 | SOURCE | gkwr 1
InPort_1274383 | SINK | cvr 7 (1)
OutPort_1274371 | SOURCE | cvr 7 (1)
InPort_1274371 | SINK | cvr 7 (1)
OutPort_1274381 | SOURCE | cvr 7 (1)
InPort_1274373 | SINK | cvr 7 (1)
OutPort_1274375 | SOURCE | cvr 7 (1)
InPort_1274381 | SINK | cvr 7 (1)
OutPort_1274373 | SOURCE | cvr 7 (1)
InPort_1274426 | SINK | cvr 7 (1)
OutPort_1274422 | SOURCE | cvr 7 (1)
InPort_1274422 | SINK | cvr 7 (1)
OutPort_1274424 | SOURCE | cvr 7 (1)
InPort_1275289 | SINK | gkwr 1
OutPort_1275293 | SOURCE | gkwr 1
InPort_1275291 | SINK | gkwr 1
OutPort_1275289 | SOURCE | gkwr 1
InPort_1275366 | SINK | cvr 7 (1)
OutPort_1275362 | SOURCE | cvr 7 (1)
InPort_1275362 | SINK | cvr 7 (1)
OutPort_1275364 | SOURCE | cvr 7 (1)
InPort_1275381 | SINK | gkwr 1
OutPort_1275385 | SOURCE | gkwr 1
InPort_1275383 | SINK | gkwr 1
OutPort_1275381 | SOURCE | gkwr 1
InPort_1275412 | SINK | cvr 7 (1)
OutPort_1275414 | SOURCE | cvr 7 (1)
InPort_1275416 | SINK | cvr 7 (1)
OutPort_1275412 | SOURCE | cvr 7 (1)
5 x InPort_1275878 | SOURCEANDSINK | cva 5
OutPort_1285646 | SOURCEANDSINK | cva 5
InPort_1275942 | SINK | cva 5
5 x OutPort_1275878 | SOURCE | cva 5
InPort_1275912 | SINK | cva 5
OutPort_1285720 | SOURCEANDSINK | cva 5
InPort_1275918 | SINK | cva 5
2 x OutPort_2743913 | SOURCEANDSINK | cva 5
OutPort_1285727 | SOURCEANDSINK | cva 5
InPort_1275880 | SINK | cva 5
2 x OutPort_1280101 | SOURCEANDSINK | cva 5
InPort_1275930 | SINK | cva 5
3 x InPort_1275884 | SINK | gkwa 2
OutPort_2743886 | SOURCE | gkwa 2
OutPort_1280522 | SOURCE | gkwa 2
InPort_1275934 | SINK | gkwa 2
5 x OutPort_1275884 | SOURCE | gkwa 2
InPort_1275886 | SINK | gkwa 2
2 x InPort_2743904 | SINK | cva 5
OutPort_1275884 | SOURCE | cva 5
InPort_1275892 | SINK | gkwa 2
InPort_1275922 | SINK | gkwa 2
OutPort_2743895 | SOURCE | gkwa 2
InPort_1275898 | SINK | gkwa 2
InPort_1275890 | SINK | gkwa 2
OutPort_1275892 | SOURCE | gkwa 2
InPort_1275894 | SINK | gkwa 2
OutPort_1275890 | SOURCE | gkwa 2
InPort_1275896 | SINK | gkwa 2
OutPort_1275898 | SOURCE | gkwa 2
InPort_1275902 | SINK | gkwa 2
OutPort_1275896 | SOURCE | gkwa 2
InPort_1275904 | SINK | gkwa 2
OutPort_1275900 | SOURCE | gkwa 2
InPort_1275900 | SINK | gkwa 2
OutPort_1275902 | SOURCE | gkwa 2
InPort_1275910 | SINK | cva 5
OutPort_1275905 | SOURCE | cva 5
InPort_1275905 | SINK | cva 5
OutPort_1275912 | SOURCE | cva 5
InPort_1275907 | SINK | cva 5
OutPort_1275910 | SOURCE | cva 5
InPort_1275909 | SINK | cva 5
OutPort_1275907 | SOURCE | cva 5
InPort_1275916 | SINK | cva 5
OutPort_1275914 | SOURCE | cva 5
InPort_1275914 | SINK | cva 5
OutPort_1275918 | SOURCE | cva 5
InPort_1275924 | SINK | gkwa 2
OutPort_1275920 | SOURCE | gkwa 2
InPort_1275920 | SINK | gkwa 2
OutPort_1275922 | SOURCE | gkwa 2
InPort_1275926 | SINK | cva 5
OutPort_1275930 | SOURCE | cva 5
InPort_1275928 | SINK | cva 5
OutPort_1275926 | SOURCE | cva 5
InPort_1275932 | SINK | gkwa 2
OutPort_1275934 | SOURCE | gkwa 2
InPort_1275936 | SINK | gkwa 2
OutPort_1275932 | SOURCE | gkwa 2
InPort_1275940 | SINK | cva 5
OutPort_1275938 | SOURCE | cva 5
InPort_1275938 | SINK | cva 5
OutPort_1275942 | SOURCE | cva 5
InPort_2743961 | SINK | gkwr 1
OutPort_1277330 | SOURCE | gkwr 1
Port_1277330 | SOURCEANDSINK | cvr 7 (1)
2 x InPort_1277330 | SOURCEANDSINK | cvr 7 (1)
OutPort_1284155 | SOURCEANDSINK | cvr 7 (1)
2 x OutPort_1285386 | SOURCEANDSINK | cvr 7 (1)
InPort_1277341 | SOURCEANDSINK | cvr 7 (1)
2 x OutPort_1284157 | SOURCEANDSINK | cvr 7 (1)
2 x InPort_1277517 | SINK | gkwr 1
OutPort_2743963 | SOURCE | gkwr 1
InPort_1284061 | SINK | gkwr 1
OutPort_1277517 | SOURCE | gkwr 1
OutPort_1285753 | SOURCE | gkwr 1
InPort_1277525 | SINK | gkwr 1
OutPort_1284071 | SOURCE | gkwr 1
InPort_1278562 | SOURCEANDSINK | cva 5
OutPort_1278564 | SOURCEANDSINK | cva 5
InPort_1278564 | SOURCEANDSINK | cva 5
2 x OutPort_2741372 | SOURCEANDSINK | cva 5
2 x InPort_1278594 | SOURCEANDSINK | cvr 7 (1)
2 x OutPort_1278608 | SOURCEANDSINK | cvr 7 (1)
OutPort_1278851 | SOURCEANDSINK | cvr 7 (1)
2 x InPort_1278600 | SOURCEANDSINK | cvr 7 (1)
2 x OutPort_2741408 | SOURCEANDSINK | cvr 7 (1)
InPort_1278851 | SOURCEANDSINK | cvr 7 (1)
InPort_1278985 | SOURCEANDSINK | cva 5
2 x InPort_1279231 | SOURCEANDSINK | cvr 7 (1)
2 x OutPort_2741393 | SOURCEANDSINK | cvr 7 (1)
2 x InPort_1279272 | SOURCEANDSINK | cva 5
2 x OutPort_2741360 | SOURCEANDSINK | cva 5
2 x InPort_1279576 | SOURCEANDSINK | cva 5
2 x OutPort_1279611 | SOURCEANDSINK | cva 5
2 x InPort_1279608 | SOURCEANDSINK | cva 5
2 x OutPort_1280097 | SOURCEANDSINK | cva 5
2 x InPort_1279638 | SOURCEANDSINK | cvr 7 (1)
OutPort_1279665 | SOURCEANDSINK | cvr 7 (1)
InPort_1279665 | SOURCEANDSINK | cvr 7 (1)
OutPort_1283501 | SOURCEANDSINK | cvr 7 (1)
2 x InPort_1280089 | SOURCEANDSINK | cva 5
InPort_1280522 | SINK | gkwa 2
OutPort_1280552 | SOURCE | gkwa 2
InPort_1280544 | SINK | gkwa 2
OutPort_2742842 | SOURCE | gkwa 2
InPort_1280552 | SINK | gkwa 2
OutPort_1280544 | SOURCE | gkwa 2
InPort_1280640 | SINK | gkwr 1
OutPort_1280619 | SOURCE | gkwr 1
InPort_1280656 | SINK | gkwr 1
OutPort_1280640 | SOURCE | gkwr 1
InPort_2742836 | SINK | gkwr 1
OutPort_1280648 | SOURCE | gkwr 1
InPort_1280648 | SINK | gkwr 1
OutPort_1280656 | SOURCE | gkwr 1
InPort_1280846 | SINK | gkwa 2
OutPort_2742840 | SOURCE | gkwa 2
InPort_2742842 | SINK | gkwa 2
OutPort_1280846 | SOURCE | gkwa 2
InPort_1281664 | SINK | gkwr 1
OutPort_2742836 | SOURCE | gkwr 1
InPort_2742834 | SINK | gkwr 1
OutPort_1281664 | SOURCE | gkwr 1
InPort_1281796 | SINK | gkwr 1
OutPort_1281843 | SOURCE | gkwr 1
InPort_1281840 | SINK | gkwr 1
OutPort_1281868 | SOURCE | gkwr 1
InPort_1282831 | SINK | gkwr 1
OutPort_1281840 | SOURCE | gkwr 1
InPort_1281843 | SINK | gkwr 1
OutPort_1282831 | SOURCE | gkwr 1
InPort_1281860 | SINK | gkwr 1
OutPort_2742834 | SOURCE | gkwr 1
InPort_1281868 | SINK | gkwr 1
OutPort_1281860 | SOURCE | gkwr 1
InPort_1281887 | SINK | gkwa 2
OutPort_1282724 | SOURCE | gkwa 2
InPort_2742840 | SINK | gkwa 2
OutPort_1281887 | SOURCE | gkwa 2
InPort_1281895 | SINK | gkwa 2
OutPort_1282726 | SOURCE | gkwa 2
InPort_1282724 | SINK | gkwa 2
OutPort_1281895 | SOURCE | gkwa 2
InPort_1282375 | SINK | gkwa 2
OutPort_1282376 | SOURCE | gkwa 2
InPort_1282376 | SINK | gkwa 2
OutPort_1282378 | SOURCE | gkwa 2
InPort_1282378 | SINK | gkwa 2
2 x OutPort_1282516 | SOURCE | gkwa 2
InPort_1282728 | SINK | gkwa 2
InPort_1282726 | SINK | gkwa 2
OutPort_1282728 | SOURCE | gkwa 2
InPort_1283501 | SOURCEANDSINK | cvr 7 (1)
OutPort_1283509 | SOURCEANDSINK | cvr 7 (1)
InPort_1283509 | SOURCEANDSINK | cvr 7 (1)
InPort_1284071 | SINK | gkwr 1
OutPort_1284061 | SOURCE | gkwr 1
InPort_1284155 | SOURCEANDSINK | cvr 7 (1)
InPort_2743963 | SINK | gkwr 1
OutPort_1284603 | SOURCE | gkwr 1
InPort_1284603 | SINK | gkwr 1
OutPort_2743961 | SOURCE | gkwr 1
Port_1285230 | SINK | cvr 7 (4)
InPort_1285376 | SOURCEANDSINK | cvr 7 (1)
Port_1285376 | SOURCEANDSINK | cvr 7 (1)
InPort_1285439 | SINK | gkwr 1
OutPort_1285438 | SOURCE | gkwr 1
InPort_1285753 | SINK | gkwr 1
OutPort_1285439 | SOURCE | gkwr 1
Port_1285646 | SOURCEANDSINK | cva 5
Port_1285720 | SOURCEANDSINK | cva 5
Port_1285727 | SOURCEANDSINK | cva 5
Port_1285966 | SOURCEANDSINK | cvr 7 (1)
2 x InPort_1285966 | SINK | cvr 7 (1)
OutPort_2743922 | SOURCE | cvr 7 (1)
OutPort_1285985 | SOURCE | cvr 7 (1)
InPort_1285966 | SOURCEANDSINK | cvr 7 (1)
OutPort_1285973 | SOURCEANDSINK | cvr 7 (1)
2 x InPort_1285968 | SINK | gkwr 1
OutPort_2743924 | SOURCE | gkwr 1
InPort_1285970 | SINK | gkwr 1
OutPort_1285968 | SOURCE | gkwr 1
OutPort_1285990 | SOURCE | gkwr 1
InPort_1285971 | SINK | gkwr 1
OutPort_1285970 | SOURCE | gkwr 1
InPort_1286161 | SINK | gkwr 1
OutPort_1285971 | SOURCE | gkwr 1
InPort_1285973 | SOURCEANDSINK | cvr 7 (1)
OutPort_1285974 | SOURCEANDSINK | cvr 7 (1)
InPort_1285974 | SOURCEANDSINK | cvr 7 (1)
InPort_2743924 | SINK | gkwr 1
OutPort_1285976 | SOURCE | gkwr 1
InPort_1285976 | SINK | gkwr 1
OutPort_2743922 | SOURCE | gkwr 1
InPort_1285983 | SINK | cvr 7 (1)
OutPort_1285982 | SOURCE | cvr 7 (1)
InPort_1285985 | SINK | cvr 7 (1)
OutPort_1285983 | SOURCE | cvr 7 (1)
InPort_1285988 | SINK | gkwr 1
OutPort_1285987 | SOURCE | gkwr 1
InPort_1285990 | SINK | gkwr 1
OutPort_1285988 | SOURCE | gkwr 1
Port_1286029 | SOURCEANDSINK | cvr 7 (1)
InPort_1286029 | SINK | cvr 7 (1)
OutPort_1286048 | SOURCE | cvr 7 (1)
InPort_2743935 | SINK | gkwr 1
OutPort_1286029 | SOURCE | gkwr 1
InPort_1286029 | SOURCEANDSINK | cvr 7 (1)
OutPort_1286036 | SOURCEANDSINK | cvr 7 (1)
2 x InPort_1286031 | SINK | gkwr 1
OutPort_1286053 | SOURCE | gkwr 1
OutPort_2743937 | SOURCE | gkwr 1
InPort_1286033 | SINK | gkwr 1
OutPort_1286031 | SOURCE | gkwr 1
InPort_1286034 | SINK | gkwr 1
OutPort_1286033 | SOURCE | gkwr 1
InPort_1286179 | SINK | gkwr 1
OutPort_1286034 | SOURCE | gkwr 1
InPort_1286036 | SOURCEANDSINK | cvr 7 (1)
OutPort_1286037 | SOURCEANDSINK | cvr 7 (1)
InPort_1286037 | SOURCEANDSINK | cvr 7 (1)
InPort_2743937 | SINK | gkwr 1
OutPort_1286039 | SOURCE | gkwr 1
InPort_1286039 | SINK | gkwr 1
OutPort_2743935 | SOURCE | gkwr 1
InPort_1286046 | SINK | cvr 7 (1)
OutPort_1286045 | SOURCE | cvr 7 (1)
InPort_1286048 | SINK | cvr 7 (1)
OutPort_1286046 | SOURCE | cvr 7 (1)
InPort_1286051 | SINK | gkwr 1
OutPort_1286050 | SOURCE | gkwr 1
InPort_1286053 | SINK | gkwr 1
OutPort_1286051 | SOURCE | gkwr 1
2 x InPort_1286119 | SINK | cvr 7 (1)
OutPort_1286138 | SOURCE | cvr 7 (1)
OutPort_2743948 | SOURCE | cvr 7 (1)
InPort_1286119 | SOURCEANDSINK | cvr 7 (1)
OutPort_1286126 | SOURCEANDSINK | cvr 7 (1)
Port_1286119 | SOURCEANDSINK | cvr 7 (1)
2 x InPort_1286121 | SINK | gkwr 1
OutPort_2743950 | SOURCE | gkwr 1
OutPort_1286143 | SOURCE | gkwr 1
InPort_1286123 | SINK | gkwr 1
OutPort_1286121 | SOURCE | gkwr 1
InPort_1286124 | SINK | gkwr 1
OutPort_1286123 | SOURCE | gkwr 1
InPort_1286197 | SINK | gkwr 1
OutPort_1286124 | SOURCE | gkwr 1
InPort_1286126 | SOURCEANDSINK | cvr 7 (1)
OutPort_1286127 | SOURCEANDSINK | cvr 7 (1)
InPort_1286127 | SOURCEANDSINK | cvr 7 (1)
InPort_2743950 | SINK | gkwr 1
OutPort_1286129 | SOURCE | gkwr 1
InPort_1286129 | SINK | gkwr 1
OutPort_2743948 | SOURCE | gkwr 1
InPort_1286136 | SINK | cvr 7 (1)
OutPort_1286135 | SOURCE | cvr 7 (1)
InPort_1286138 | SINK | cvr 7 (1)
OutPort_1286136 | SOURCE | cvr 7 (1)
InPort_1286141 | SINK | gkwr 1
OutPort_1286140 | SOURCE | gkwr 1
InPort_1286143 | SINK | gkwr 1
OutPort_1286141 | SOURCE | gkwr 1
InPort_1286390 | SINK | cva 5
2 x OutPort_1286378 | SOURCE | cva 5
Port_1286378 | SOURCEANDSINK | cva 5
InPort_1286397 | SINK | cva 5
InPort_1286378 | SOURCEANDSINK | cva 5
OutPort_1286385 | SOURCEANDSINK | cva 5
InPort_1286382 | SINK | cva 5
2 x OutPort_1286380 | SOURCE | cva 5
InPort_1286380 | SINK | cva 5
OutPort_1286392 | SOURCE | cva 5
InPort_1286402 | SINK | cva 5
InPort_1286383 | SINK | cva 5
OutPort_1286382 | SOURCE | cva 5
OutPort_1286383 | SOURCE | cva 5
InPort_1286385 | SOURCEANDSINK | cva 5
OutPort_1286386 | SOURCEANDSINK | cva 5
InPort_1286386 | SOURCEANDSINK | cva 5
InPort_1286388 | SINK | cva 5
OutPort_1286390 | SOURCE | cva 5
InPort_1286392 | SINK | cva 5
OutPort_1286388 | SOURCE | cva 5
InPort_1286394 | SINK | cva 5
OutPort_1286395 | SOURCE | cva 5
InPort_1286395 | SINK | cva 5
OutPort_1286397 | SOURCE | cva 5
InPort_1286399 | SINK | cva 5
OutPort_1286400 | SOURCE | cva 5
InPort_1286400 | SINK | cva 5
OutPort_1286402 | SOURCE | cva 5
InPort_1300411 | SINK | mvt lbk1
OutPort_2018915 | SOURCE | mvt lbk1
InPort_1300412 | SINK | mvt lbk1
OutPort_2018913 | SOURCE | mvt lbk1
