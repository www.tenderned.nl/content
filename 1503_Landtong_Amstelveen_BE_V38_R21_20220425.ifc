Properties of the parts of a building model (IFC2X3), part 11 of 13

# IfcFlowSegment: Flex Duct Round:Flex - Round (188)
Name (Flex Duct Round:Flex - Round:...) | In | Length (mm) | Group
1998280 | 01 | 673.723 | mvr 5
2000085 | 01 | 1007.52 | mvt lbk1
2000087 | 01 | 1007.52 | mvt lbk1
2002143 | 01 | 1017.2 | mvt lbk1
2002145 | 01 | 1017.2 | mvt lbk1
2002209 | 01 | 1017.2 | mvt lbk1
2002211 | 01 | 1017.2 | mvt lbk1
2002533 | 01 | 1017.2 | mvt lbk1
2002535 | 01 | 1017.2 | mvt lbk1
2009473 | 01 | 1017.2 | mvt lbk1
2009475 | 01 | 1017.2 | mvt lbk1
2015218 | 01 | 1014.13 | mvt lbk1
2016629 | 01 | 1009.13 | mvt lbk1
2016631 | 01 | 1009.13 | mvt lbk1
2017620 | 01 | 1022.57 | mvr 5
2017622 | 01 | 1022.57 | mvr 5
2017624 | 01 | 1091.99 | mvr 5
2018913 | 01 | 1017.12 | mvt lbk1
2018915 | 01 | 1017.12 | mvt lbk1
2019076 | 01 | 1091.16 | mvt lbk1
2021631 | 01 | 1000 | mvr 5
2021633 | 01 | 1000 | mvr 5
2026655 | 01 | 1000 | mvr 5
2031111 | 01 | 1000 | mvr 5
2031851 | 01 | 1000 | mvr 5
2032652 | 01 | 817.549 | mvr 5
2032654 | 01 | 762.825 | mvr 5
2032727 | 01 | 1257.3 | mvr 5
2032736 | 01 | 1033.85 | mvr 5
2035402 | 01 | 974.411 | mvr 5
2036960 | 01 | 824.934 | mvr 5
2037020 | 01 | 827.495 | mvr 5
2037022 | 01 | 827.495 | mvr 5
2037487 | 01 | 953.534 | mvr 5
2050112 | 01 | 1257.3 | mvr 5
2050128 | 01 | 1257.3 | mvr 5
2050437 | 01 | 1282.59 | mvr 5
2053142 | 01 | 741.53 | mvr 5
2062005 | 00 | 804.208 | mvr 5
2063522 | 00 | 1000.5 | mvt lbk1
2063524 | 00 | 1000.5 | mvt lbk1
2066322 | 00 | 1043.01 | mvt lbk1
2066324 | 00 | 1114.67 | mvt lbk1
2071404 | 00 | 856.135 | mvr 5
2071406 | 00 | 856.135 | mvr 5
2073232 | 00 | 724.778 | mvr 5
2073569 | 00 | 955.479 | mvt lbk1
2077954 | 00 | 442.877 | mvt lbk1
2126456 | 00 | 1047.32 | mvt lbk1
2126458 | 00 | 1047.32 | mvt lbk1
2150327 | 00 | 869.159 | mvr 5
2150681 | 00 | 869.159 | mvr 5
2161431 | 00 | 1000 | mvr 5
2163895 | 01 | 715.058 | mvr 5
2163897 | 01 | 715.058 | mvr 5
2183771 | 01 | 954.921 | mvr 5
2184282 | 01 | 849.091 | mvr 5
2184850 | 01 | 1000 | mvr 5
2184852 | 01 | 1000 | mvr 5
2194107 | 01 | 919.371 | mvr 5
2201299 | 01 | 905 | mvt lbk1
2202718 | 01 | 1000 | mvr 5
2204098 | 01 | 493.429 | mvr 5
2204100 | 01 | 493.429 | mvr 5
2204102 | 01 | 493.429 | mvr 5
2204982 | 01 | 794.93 | mvt lbk1
2205833 | 01 | 1130.15 | mvr 5
2213158 | 01 | 799.559 | mvr 5
2213162 | 01 | 799.559 | mvr 5
2213587 | 01 | 1293.39 | mvr 5
2213624 | 01 | 1051.25 | mvr 5
2216548 | 00 | 1452.45 | mvr 5
2222023 | 00 | 912.051 | mvt lbk1
2222028 | 00 | 912.051 | mvt lbk1
2226762 | 00 | 1000 | mvr 5
2231082 | 00 | 1000 | mvr 5
2234287 | 00 | 1225 | mvr 5
2234319 | 00 | 880.583 | mvr 5
2306263 | 00 | 1373.82 | mvt lbk1
2309162 | 00 | 1000 | mvr 5
2314560 | 01 | 928.646 | mvt lbk1
2317285 | 00 | 937.448 | mvt lbk1
2319539 | 00 | 905.71 | mvr 5
2320023 | 00 | 917.5 | mvr 5
2320142 | 00 | 905.71 | mvr 5
2320153 | 00 | 917.5 | mvr 5
2321292 | 00 | 966.01 | mvr 5
2322774 | 00 | 931.14 | mvt lbk1
2322776 | 00 | 951.782 | mvt lbk1
2323466 | 00 | 928.64 | mvt lbk1
2323470 | 00 | 928.64 | mvt lbk1
2323513 | 00 | 931.14 | mvt lbk1
2323515 | 00 | 1007.8 | mvt lbk1
2324610 | 00 | 1000 | mvr 5
2326642 | 00 | 1000 | mvr 5
2338724 | 00 | 1000 | mvr 5
2436190 | 01 | 1015.73 | mvt 2
2436192 | 01 | 1015.73 | mvt 2
2436214 | 01 | 1056.17 | mvt 2
2436216 | 01 | 1056.17 | mvt 2
2436222 | 01 | 1022.57 | mvt 2
2436224 | 01 | 1022.57 | mvt 2
2436249 | 01 | 944.937 | mvt 2
2436251 | 01 | 1256.74 | mvt 2
2436312 | 01 | 950.03 | mvt 2
2436348 | 01 | 1169.91 | mvt 2
2481627 | 01 | 832.763 | mvr 5
2530435 | 01 | 1006.64 | mvt lbk1
2530437 | 01 | 1006.64 | mvt lbk1
2530439 | 01 | 1006.64 | mvt lbk1
2530441 | 01 | 1006.64 | mvt lbk1
2560445 | 01 | 1007.57 | mvt lbk1
2560447 | 01 | 1007.57 | mvt lbk1
2576772 | 00 | 943.805 | mvr 5
2576774 | 00 | 943.805 | mvr 5
2576776 | 00 | 1036.85 | mvr 5
2576829 | 00 | 908.069 | mvr 5
2576837 | 00 | 908.069 | mvr 5
2577050 | 00 | 843.888 | mvr 5
2578548 | 00 | 476.985 | mvr 5
2581604 | 00 | 762.5 | mvr 5
2582229 | 00 | 949.586 | mvt lbk1
2582294 | 00 | 1003.16 | mvt lbk1
2583219 | 00 | 810.821 | mvr 5
2584041 | 00 | 1000 | mvr 5
2585081 | 00 | 791.232 | mvr 5
2590120 | 00 | 819.189 | mvr 5
2593557 | 00 | 894.854 | mvt lbk1
2594642 | 00 | 760.592 | mvt lbk1
2600897 | 01 | 800 | mvr 5
2601480 | 01 | 639.539 | mvr 5
2606877 | 02 | 1035 | mvr 5
2611243 | 00 | 998.352 | mvt lbk1
2611245 | 00 | 998.352 | mvt lbk1
2612100 | 00 | 587.567 | mvt lbk1
2612102 | 00 | 1016.51 | mvt lbk1
2617578 | 01 | 1025.84 | mvt 2
2641182 | 00 | 655.257 | mvr 5
2725912 | 00 | 915.215 | mvt lbk1
2880724 | 00 | 804.895 | mvr 5

# IfcFlowSegment: NLRS_52_PIF_UN_DS pipe_SH_Dyka:var. DN/OD, NLRS_52_PIF_UN_DS pipe_SH_Dyka:var. DN/OD:2048756
In: 00
Type - Description: DykaSono Pipe; PredefinedType: RIGIDSEGMENT; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_blauw_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: var. DN/OD; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 250 mm; sets with these values: 2
Pset_PipeSegmentTypeCommon - OuterDiameter: 110

# IfcFlowSegment: NLRS_52_PIF_UN_HWA PVC buis VK_Dyka:Grijs, var. DN/OD (36)
Type - Description: Dyka pipe square; PredefinedType: RIGIDSEGMENT; Classification: 52.10 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Grijs, var. DN/OD; sets with these values: 2
Name (NLRS_52_PIF_UN_HWA PVC buis VK_Dyka:Grijs, var. DN/OD:...) | In | Group
2498855 | 01 | hwa 2 | Pset_FlowSegmentDuctSegment - Length: 100 mm; sets with these values: 2
2498904 | 01 | hwa 8
2498981 | 01 | hwa 9
2499025 | 01 | hwa 10
2499182 | 01 | hwa 2
2499207 | 01 | hwa 2
2499290 | 01 | hwa 2
2499315 | 01 | hwa 2
2499334 | 01 | hwa 2
2499359 | 01 | hwa 2
2499378 | 01 | hwa 2
2499403 | 01 | hwa 2
2499422 | 01 | hwa 2
2499447 | 01 | hwa 2
2499546 | 01 | hwa 2
2500344 | 01 | hwa 2
2500374 | 01 | hwa 2
2500404 | 01 | hwa 2
2501053 | 01 | hwa 2
2501067 | 01 | hwa 2
2501096 | 01 | hwa 2
2501110 | 01 | hwa 2
2501141 | 01 | hwa 2
2501155 | 01 | hwa 2
2501186 | 01 | hwa 2
2501200 | 01 | hwa 2
2503247 | 01 | hwa 2
2503253 | 01 | hwa 2
2521463 | 00 | hwa 1
2523612 | 00 | hwa 3
2825851 | 01 | hwa 2
2825861 | 01 | hwa 2
2888677 | 01 | hwa 2
2889405 | 01 | hwa 2 | Pset_FlowSegmentDuctSegment - Length: 100 mm; sets with these values: 2
2891226 | 02 | hwa 2
2906300 | 01 | hwa 2

# IfcFlowSegment: NLRS_52_PIF_UN_PVC pipe_SH_Dyka:var. DN/OD (nested), NLRS_52_PIF_UN_PVC pipe_SH_Dyka:var. DN/OD (nested):2120991
In: 00
Type - Description: Dyka Pipe; PredefinedType: RIGIDSEGMENT; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: var. DN/OD (nested); sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 250 mm; sets with these values: 2
Pset_PipeSegmentTypeCommon - OuterDiameter: 110

# IfcFlowSegment: Pipe Types:Aquatherm Blue Pipe SDR 7.4 MF - 11 MF RP - t-stukken (527)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Aquatherm
Type - Pset_ProductRequirements - Category: Pipes
Pset_DistributionFlowElementCommon - Reference: Aquatherm Blue Pipe SDR 7.4 MF - 11 MF RP - t-stukken; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.00254 mm
Name (Pipe Types:Aquatherm Blue Pipe SDR 7.4 MF - 11 MF RP - t-stukken:...) | In | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
2147886 | 00 | 28100.9 | 3259.51 | cva 8
2147896 | 01 | 27950.9 | 3259.51 | cvr 24
2147905 | 01 | 27782.9 | 3251.51 | cva 10
2147911 | 01 | 2302.09 | 3297.91 | cvr 23
2147914 | 01 | 27632.9 | 3251.51 | cvr 23
2147926 | 00 | 2511.6 | 3251.51 | cva 20
2147932 | 00 | 5357.79 | 3255.61 | cva 20
2147934 | 00 | 763 | 3255.61 | cva 20
2147936 | 00 | 2583.55 | 3255.61 | cva 20
2147938 | 00 | 7765.58 | 3255.61 | cva 20
2147965 | 00 | 5307.79 | 3255.61 | cvr 11
2147967 | 00 | 763 | 3255.61 | cvr 11
2147969 | 00 | 2883.55 | 3255.61 | cvr 11
2147971 | 00 | 7765.58 | 3255.61 | cvr 11
2147989 | 00 | 4964.5 | 3255.61 | cva 20
2147991 | 00 | 4814.5 | 3255.61 | cvr 11
2148017 | 00 | 4566 | 3349.5 | cvr 1
2148021 | 00 | 733.004 | 3349.5 | cvr 1
2148025 | 00 | 4566 | 3349.5 | cva 1
2256772 | 00 | 3932.75 | 3042.8 | cvr 1
2256792 | 00 | 883.004 | 3349.5 | cva 1
2257754 | 00 | 4769.01 | 3042.8 | cva 1
2258501 | 00 | 458.988 | 3142.8 | cva 20
2258503 | 00 | 983.05 | 3042.8 | cvr 11
2259465 | 00 | 112.946 | 192.8 | cva 20
2259470 | 00 | 2823 | 213.5 | cva 20
2259487 | 00 | 12.946 | 392.8 | cvr 11
2259492 | 00 | 2623 | 413.5 | cvr 11
2259590 | 00 | 434.538 | 3042.8 | cva 20
2259623 | 00 | 484.538 | 3042.8 | cvr 11
2259684 | 00 | 1669.39 | 3042.8 | cvr 11
2259802 | 00 | 555.5 | 3042.8 | cvr 11
2259903 | 00 | 1898.91 | 213.5 | cva 20
2259905 | 00 | 178.608 | 2118.71 | cva 20
2259907 | 00 | 1317.47 | 2118.71 | cva 20
2259909 | 00 | 902.091 | 2136.91 | cva 20
2259919 | 00 | 112.946 | 192.8 | cva 20
2259924 | 00 | 630.5 | 3042.8 | cva 20
2260438 | 00 | 93.4101 | 3163.5 | cva 20
2260489 | 00 | 93.4101 | 3163.5 | cvr 11
2261308 | 00 | 1669.39 | 3042.8 | cva 20
2261314 | 00 | 70.5 | 3063.5 | cva 20
2261384 | 00 | 7592.51 | 3141 | cva 20
2261399 | 00 | 70.5 | 3063.5 | cvr 11
2261432 | 00 | 7342.51 | 3141 | cvr 11
2261494 | 00 | 558.988 | 3142.8 | cvr 11
2261503 | 00 | 78 | 3061 | cvr 11
2261530 | 00 | 908.05 | 3042.8 | cva 20
2261596 | 00 | 78 | 3061 | cva 20
2262041 | 00 | 2819 | 213.5 | cva 20
2262043 | 00 | 533 | 3038.8 | cva 20
2262049 | 00 | 12.946 | 192.8 | cva 20
2262054 | 00 | 1633 | 3038.8 | cva 20
2262062 | 00 | 2619 | 413.5 | cvr 11
2262064 | 00 | 473 | 3038.8 | cvr 11
2262070 | 00 | 12.946 | 392.8 | cvr 11
2262075 | 00 | 1683 | 3038.8 | cvr 11
2262380 | 00 | 4973 | 3038.8 | cva 20
2262433 | 00 | 4873 | 3038.8 | cvr 11
2262534 | 00 | 166.85 | 3118.8 | cvr 11
2262923 | 00 | 117.41 | 3139.5 | cvr 11
2262967 | 00 | 117.41 | 3139.5 | cva 20
2263019 | 00 | 8888.52 | 3262.91 | cva 20
2263039 | 00 | 9148.52 | 3262.91 | cvr 11
2263428 | 00 | 188 | 3063.91 | cvr 11
2263468 | 00 | 88 | 3163.91 | cva 20
2263513 | 00 | 7428.15 | 3255.61 | cva 20
2263533 | 00 | 2038.85 | 3255.61 | cvr 11
2263542 | 00 | 86.946 | 191 | cva 20
2263547 | 00 | 2923.41 | 213.5 | cva 20
2263553 | 00 | 154 | 391 | cvr 11
2263680 | 00 | 7728.42 | 3141.41 | cva 20
2263688 | 00 | 377.792 | 3141.41 | cva 20
2264003 | 00 | 272.554 | 3141.41 | cva 20
2264011 | 00 | 88.554 | 3141.41 | cva 20
2264066 | 00 | 7678.42 | 3041.41 | cvr 11
2264131 | 00 | 221.054 | 391 | cvr 11
2264254 | 00 | 529.292 | 3041.41 | cvr 11
2264427 | 00 | 2619.91 | 417 | cvr 11
2264460 | 00 | 135.446 | 391 | cvr 11
2264809 | 00 | 1238.05 | 3345.6 | cvr 1
2300961 | 00 | 1088.05 | 3345.6 | cva 1
2521095 | 00 | 4229.57 | 3349.5 | cvr 1
2521115 | 00 | 4180.76 | 3349.5 | cva 1
2521389 | 00 | 5445.05 | 3345.6 | cva 1
2521409 | 00 | 5395.05 | 3345.6 | cvr 1
2550450 | 00 | 284.9 | 3061 | cvr 1
2550476 | 00 | 284.9 | 3061 | cva 1
2551209 | 00 | 3832.75 | 3042.8 | cva 1
2551239 | 00 | 4702.16 | 3042.8 | cvr 1
2551264 | 00 | 898 | 3042.8 | cvr 1
2551312 | 00 | 898 | 3042.8 | cva 1
2551553 | 00 | 705.417 | 3042.8 | cvr 11
2551580 | 00 | 680.417 | 3042.8 | cva 20
2595261 | 00 | 390.55 | 3038.8 | cvr 11
2595441 | 00 | 488 | 3038.8 | cva 20
2596089 | 00 | 58 | 3057 | cva 20
2596103 | 00 | 69.3588 | 3118.8 | cva 20
2596168 | 00 | 7404.69 | 3117 | cva 20
2596252 | 00 | 58 | 3057 | cvr 11
2596312 | 00 | 7154.65 | 3117 | cvr 11
2715872 | 00 | 27792.9 | 3148.7 | gkwa 3
2715879 | 00 | 28092.9 | 3148.7 | gkwr 2
2716214 | 00 | 1963 | 3148.7 | gkwr 2
2716229 | 00 | 3183.6 | 3148.7 | gkwr 2
2716287 | 00 | 7765.6 | 3148.7 | gkwr 2
2716295 | 00 | 12919.5 | 3148.7 | gkwr 2
2716446 | 00 | 1963 | 3148.7 | gkwa 3
2716455 | 00 | 3483.6 | 3148.7 | gkwa 3
2716464 | 00 | 7765.6 | 3148.7 | gkwa 3
2716473 | 00 | 12859.5 | 3148.7 | gkwa 3
2716995 | 00 | 118 | 3145.3 | gkwa 3
2717150 | 00 | 109 | 3145.3 | gkwa 3
2717186 | 00 | 2924 | 3145.3 | gkwa 3
2717294 | 00 | 50 | 3145.3 | gkwa 3
2717307 | 00 | 60 | 3145.3 | gkwa 3
2717350 | 00 | 2500.06 | 3145.3 | gkwa 3
2717436 | 00 | 414.675 | 3145.3 | gkwa 3
2717450 | 00 | 1295 | 3145.3 | gkwa 3
2717454 | 00 | 1284 | 3145.3 | gkwa 3
2717459 | 00 | 414.675 | 3145.3 | gkwa 3
2717486 | 00 | 110 | 3145.3 | gkwa 3
2717506 | 00 | 103 | 3145.3 | gkwa 3
2717534 | 00 | 60 | 3145.3 | gkwa 3
2717546 | 00 | 86.0586 | 3145.3 | gkwa 3
2717808 | 00 | 583.074 | 3145.3 | gkwa 3
2726682 | 00 | 502.157 | 3148.7 | gkwa 3
2726712 | 00 | 682.157 | 3148.7 | gkwr 2
2726757 | 00 | 405.264 | 3148.7 | gkwr 2
2726805 | 00 | 405.264 | 3148.7 | gkwa 3
2726855 | 00 | 405.264 | 3148.7 | gkwr 2
2726859 | 00 | 405.264 | 3148.7 | gkwa 3
2727002 | 00 | 4757.31 | 3148.7 | gkwa 3
2727234 | 00 | 405.264 | 3148.7 | gkwa 3
2727264 | 00 | 4765.84 | 3148.7 | gkwr 2
2727270 | 00 | 293.132 | 3148.7 | gkwr 2
2727368 | 00 | 6156.24 | 3148.7 | gkwa 3
2727385 | 00 | 241 | 3148.7 | gkwa 3
2727395 | 00 | 681 | 3148.7 | gkwa 3
2727403 | 00 | 341 | 3148.7 | gkwa 3
2727465 | 00 | 6297.78 | 3148.7 | gkwr 2
2727473 | 00 | 199.579 | 3148.7 | gkwr 2
2727483 | 00 | 598.156 | 3148.7 | gkwr 2
2727491 | 00 | 431.711 | 3148.7 | gkwr 2
2727610 | 00 | 5496.39 | 3148.7 | gkwa 3
2727639 | 00 | 5496.39 | 3148.7 | gkwr 2
2727962 | 00 | 1068.45 | 3148.7 | gkwa 3
2728064 | 00 | 978.454 | 3148.7 | gkwr 2
2728262 | 00 | 119 | 3370.3 | gkwr 2
2728264 | 00 | 110 | 3370.3 | gkwr 2
2728268 | 00 | 2924 | 3370.3 | gkwr 2
2728272 | 00 | 50 | 3370.3 | gkwr 2
2728274 | 00 | 60 | 3370.3 | gkwr 2
2728280 | 00 | 2500.06 | 3370.3 | gkwr 2
2728285 | 00 | 414.675 | 3370.3 | gkwr 2
2728489 | 00 | 811.107 | 3370.3 | gkwr 2
2728499 | 00 | 180 | 3186.5 | gkwr 2
2728539 | 00 | 46.4846 | 3146.1 | gkwa 3
2728558 | 00 | 874.942 | 3148.7 | gkwa 3
2728798 | 00 | 583.074 | 3145.3 | gkwa 3
2728834 | 00 | 852.152 | 3148.7 | gkwr 2
2728875 | 00 | 190.5 | 3176 | gkwr 2
2728877 | 00 | 56.9846 | 3146.1 | gkwa 3
2728975 | 00 | 1295 | 3370.3 | gkwr 2
2728977 | 00 | 1284 | 3370.3 | gkwr 2
2728982 | 00 | 414.675 | 3370.3 | gkwr 2
2728985 | 00 | 110 | 3370.3 | gkwr 2
2728989 | 00 | 103 | 3370.3 | gkwr 2
2728993 | 00 | 60 | 3370.3 | gkwr 2
2728997 | 00 | 86.0586 | 3370.3 | gkwr 2
2729001 | 00 | 811.107 | 3370.3 | gkwr 2
2743479 | 00 | 2321.58 | -1234 | bra 3
2743685 | 00 | 2656.58 | -1464 | brr 1
2744075 | 00 | 18047.5 | 3259.51 | cva 8
2744134 | 00 | 3152.78 | 3251.51 | cvr 11
2744142 | 00 | 3122.51 | 3251.51 | cvr 11
2744222 | 00 | 18270.7 | 3251.51 | cvr 23
2744288 | 00 | 4383.18 | 3251.51 | cvr 23
2744325 | 00 | 17729.5 | 3251.51 | cva 10
2744356 | 00 | 18738.7 | 3259.51 | cvr 24
2744364 | 00 | 5661.84 | 3259.51 | cvr 24
2744709 | 00 | 737 | 2517.91 | cva 8
2744762 | 00 | 212.625 | 2348.55 | cva 8
2744780 | 00 | 214 | 2133.08 | cva 8
2744812 | 00 | 468 | 2777.91 | cva 20
2744820 | 00 | 1110.17 | 2731.51 | cva 20
2744830 | 00 | 592.834 | 2133.08 | cva 20
2744851 | 00 | 708 | 2537.91 | cva 10
2744861 | 00 | 450.166 | 2491.51 | cva 10
2744871 | 00 | 352.834 | 2133.08 | cva 10
2744907 | 00 | 807.183 | 3259.51 | cvr 24
2744917 | 00 | 1123 | 2131.91 | cvr 24
2744942 | 00 | 639.183 | 3251.51 | cvr 23
2744952 | 00 | 1134 | 2111.91 | cvr 23
2744977 | 00 | 489.183 | 3251.51 | cvr 11
2744985 | 00 | 1114 | 2131.91 | cvr 11
2745303 | 00 | 1050.16 | 3141.2 | cva 1
2745316 | 00 | 6276.28 | 3141.2 | cva 1
2745443 | 00 | 2042.94 | 3141.2 | cvr 1
2745734 | 00 | 258.565 | 3152.69 | cvr 1
2745771 | 00 | 258.565 | 3152.69 | cva 1
2745857 | 00 | 1320.16 | 3141.2 | cvr 1
2746004 | 00 | 949.183 | 3141.2 | cva 1
2746012 | 00 | 1019 | 2117.5 | cva 1
2746068 | 00 | 1099.16 | 2933.7 | cvr 1
2746076 | 00 | 791.5 | 2137.5 | cvr 1
2746105 | 00 | 19480.7 | 3148.7 | gkwr 2
2746207 | 00 | 18439.5 | 3148.7 | gkwa 3
2746215 | 00 | 539 | 2605 | gkwa 3
2746529 | 00 | 110.921 | 3068.32 | gkwr 2
2746539 | 00 | 849.183 | 3048.7 | gkwr 2
2746549 | 00 | 2719 | 325 | gkwr 2
2746619 | 00 | 4489.5 | 3148.7 | gkwr 2
2756844 | 00 | 2642.5 | 3255.61 | cvr 11
2756882 | 00 | 2742.5 | 3255.61 | cva 20
2756937 | 00 | 1138.66 | 3105.61 | cvr 11
2756965 | 00 | 1138.66 | 3105.61 | cva 20
2757105 | 00 | 193.132 | 3117.1 | cvr 11
2757140 | 00 | 193.132 | 3117.1 | cvr 11
2757221 | 00 | 193.132 | 3117.1 | cva 20
2757298 | 00 | 193.132 | 3117.1 | cva 20
2780371 | 00 | 1528.24 | 3141.2 | cvr 1
2780445 | 00 | 1798.22 | 3141.2 | cva 1
2801427 | 01 | 2452.09 | 3297.91 | cva 10
2801564 | 01 | 877.949 | 5605.6 | cvr 23
2801637 | 01 | 1027.95 | 5755.6 | cva 10
2801645 | 01 | 652 | 5755.6 | cva 10
2801813 | 01 | 652 | 5605.6 | cvr 23
2801821 | 01 | 2554 | 5605.6 | cvr 23
2801935 | 01 | 2554 | 5755.6 | cva 10
2802265 | 01 | 6099.09 | 3288.91 | cvr 24
2802290 | 01 | 6249.09 | 3288.91 | cva 8
2802614 | 01 | 662.905 | 9542.6 | cva 8
2802628 | 01 | 653 | 9572 | cva 8
2802666 | 01 | 587.595 | 9572 | cva 8
2802683 | 01 | 5463.59 | 9542.6 | cva 8
2802686 | 01 | 35.6631 | 10163.6 | cva 8
2802725 | 01 | 6426.5 | 9392.6 | cvr 24
2802740 | 01 | 323 | 9422 | cvr 24
2802829 | 01 | 541.185 | 9542.6 | cva 8
2802898 | 01 | 541.185 | 9392.6 | cvr 24
2830781 | 00 | 459.745 | 4067.8 | cva 1
2830783 | 00 | 998 | 3063.5 | cva 1
2830785 | 00 | 1240.95 | 3042.8 | cva 1
2830793 | 01 | 12.946 | 4067.8 | cva 1
2830829 | 00 | 526.6 | 4267.8 | cvr 1
2830831 | 00 | 1048 | 3213.5 | cvr 1
2830833 | 00 | 1388.45 | 3192.8 | cvr 1
2830841 | 00 | 125.5 | 3061 | cvr 1
2830857 | 01 | 112.946 | 4267.8 | cvr 1
2830878 | 00 | 2823 | 213.5 | cva 1
2830880 | 00 | 12.946 | 192.8 | cva 1
2830885 | 00 | 512.299 | 3042.8 | cva 1
2830898 | 00 | 2623 | 413.5 | cvr 1
2830900 | 00 | 12.946 | 392.8 | cvr 1
2830905 | 00 | 629.154 | 3042.8 | cvr 1
2830918 | 00 | 686.1 | 3375.4 | cva 1
2830920 | 00 | 562.493 | 3354.7 | cva 1
2830926 | 00 | 13304.6 | 3354.7 | cva 1
2830939 | 01 | 12.946 | 4067.8 | cva 1
2830950 | 00 | 51.2107 | 4224.15 | cvr 1
2830952 | 00 | 843.6 | 3375.4 | cvr 1
2830954 | 00 | 412.493 | 3354.7 | cvr 1
2830964 | 00 | 13154.6 | 3354.7 | cvr 1
2830971 | 01 | 112.946 | 4267.8 | cvr 1
2830992 | 00 | 2895 | 213.5 | cva 1
2830994 | 00 | 562.493 | 3114.8 | cva 1
2831000 | 00 | 12.946 | 192.8 | cva 1
2831005 | 00 | 210.4 | 3135.5 | cva 1
2831014 | 00 | 4112.95 | 3352.9 | cva 1
2831029 | 00 | 2781.91 | 413.5 | cvr 1
2831031 | 00 | 462.493 | 3201.71 | cvr 1
2831037 | 00 | 12.946 | 392.8 | cvr 1
2831042 | 00 | 123.49 | 3222.41 | cvr 1
2831051 | 00 | 4162.95 | 3352.9 | cvr 1
2831067 | 00 | 773 | 3288.5 | cva 1
2831069 | 00 | 542.993 | 3267.8 | cva 1
2831075 | 00 | 56.9 | 3288.5 | cva 1
2831084 | 00 | 4093.5 | 3352.9 | cva 1
2831091 | 01 | 12.946 | 4067.8 | cva 1
2831107 | 00 | 51.2107 | 4224.15 | cvr 1
2831109 | 00 | 843.6 | 3375.4 | cvr 1
2831115 | 00 | 389.993 | 3354.7 | cvr 1
2831124 | 00 | 4193.5 | 3352.9 | cvr 1
2831131 | 01 | 112.946 | 4267.8 | cvr 1
2831143 | 00 | 51.2107 | 4024.15 | cva 1
2831145 | 00 | 730.5 | 3288.5 | cva 1
2831147 | 00 | 562.493 | 3267.8 | cva 1
2831155 | 00 | 56.9 | 3288.5 | cva 1
2831164 | 00 | 290.608 | 3349.5 | cva 1
2831171 | 01 | 112.946 | 4067.8 | cva 1
2831185 | 00 | 886.1 | 3375.4 | cvr 1
2831189 | 00 | 409.493 | 3354.7 | cvr 1
2831198 | 00 | 290.608 | 3349.5 | cvr 1
2831205 | 01 | 12.946 | 4267.8 | cvr 1
2831216 | 00 | 2781.91 | 413.5 | cvr 1
2831218 | 00 | 462.493 | 3201.71 | cvr 1
2831224 | 00 | 12.946 | 392.8 | cvr 1
2831229 | 00 | 122.99 | 3222.41 | cvr 1
2831238 | 00 | 6031.39 | 3349.5 | cvr 1
2831251 | 00 | 2855 | 213.5 | cva 1
2831253 | 00 | 562.493 | 3074.8 | cva 1
2831255 | 00 | 249.9 | 3095.5 | cva 1
2831263 | 00 | 12.946 | 192.8 | cva 1
2831278 | 01 | 192.946 | 4267.8 | cvr 1
2831280 | 01 | 1135.5 | 3126 | cvr 1
2831282 | 01 | 185.386 | 3105.3 | cvr 1
2831299 | 00 | 214.4 | 3126 | cvr 1
2831301 | 00 | 5932.55 | 3105.3 | cvr 1
2831315 | 01 | 192.946 | 4067.8 | cva 1
2831317 | 01 | 935.5 | 3126 | cva 1
2831319 | 01 | 84.1894 | 3105.3 | cva 1
2831336 | 00 | 214.4 | 3126 | cva 1
2831338 | 00 | 5782.55 | 3105.3 | cva 1
2831351 | 00 | 785 | 3276.5 | cva 1
2831353 | 00 | 1354.79 | 3255.8 | cva 1
2831355 | 00 | 128.5 | 3123.5 | cva 1
2831363 | 01 | 112.946 | 4067.8 | cva 1
2831374 | 00 | 848.1 | 3413.4 | cvr 1
2831376 | 00 | 1505.98 | 3392.7 | cvr 1
2831378 | 00 | 265.4 | 3123.5 | cvr 1
2831386 | 01 | 12.946 | 4267.8 | cvr 1
2831396 | 00 | 2746.41 | 413.5 | cvr 1
2831398 | 00 | 265.166 | 3165.07 | cvr 1
2831404 | 00 | 12.946 | 392.8 | cvr 1
2831411 | 00 | 266.007 | 3354.7 | cvr 1
2831420 | 00 | 828.929 | 3345.6 | cvr 1
2831435 | 00 | 2873 | 213.5 | cva 1
2831437 | 00 | 562.493 | 3092.8 | cva 1
2831443 | 00 | 12.946 | 192.8 | cva 1
2831448 | 00 | 226.9 | 3113.5 | cva 1
2831457 | 00 | 727.732 | 3345.6 | cva 1
2831472 | 00 | 2746.41 | 413.5 | cvr 1
2831474 | 00 | 265.166 | 3165.07 | cvr 1
2831480 | 00 | 12.946 | 392.8 | cvr 1
2831487 | 00 | 266.007 | 3354.7 | cvr 1
2831496 | 00 | 7983 | 3345.6 | cvr 1
2831509 | 00 | 2873 | 213.5 | cva 1
2831511 | 00 | 562.493 | 3092.8 | cva 1
2831517 | 00 | 12.946 | 192.8 | cva 1
2831522 | 00 | 226.9 | 3113.5 | cva 1
2831531 | 00 | 7983 | 3345.6 | cva 1
2831546 | 00 | 1135.5 | 3126 | cvr 1
2831548 | 00 | 1378.06 | 3105.3 | cvr 1
2831554 | 00 | 214.4 | 3126 | cvr 1
2831559 | 01 | 12.946 | 4267.8 | cvr 1
2831572 | 00 | 935.5 | 3126 | cva 1
2831574 | 00 | 1228.06 | 3105.3 | cva 1
2831580 | 00 | 214.4 | 3126 | cva 1
2831585 | 01 | 12.946 | 4067.8 | cva 1
2831598 | 00 | 2746.41 | 413.5 | cvr 1
2831600 | 00 | 265.166 | 3165.07 | cvr 1
2831606 | 00 | 12.946 | 392.8 | cvr 1
2831613 | 00 | 266.007 | 3354.7 | cvr 1
2831622 | 00 | 1820.95 | 3345.6 | cvr 1
2831635 | 00 | 2873 | 213.5 | cva 1
2831637 | 00 | 562.493 | 3092.8 | cva 1
2831643 | 00 | 12.946 | 192.8 | cva 1
2831648 | 00 | 226.9 | 3113.5 | cva 1
2831657 | 00 | 1770.95 | 3345.6 | cva 1
2831672 | 00 | 2746.41 | 413.5 | cvr 1
2831674 | 00 | 265.166 | 3165.07 | cvr 1
2831680 | 00 | 12.946 | 392.8 | cvr 1
2831687 | 00 | 276.507 | 3354.7 | cvr 1
2831696 | 00 | 7212.5 | 3345.6 | cvr 1
2831709 | 00 | 2873 | 213.5 | cva 1
2831711 | 00 | 562.493 | 3092.8 | cva 1
2831717 | 00 | 12.946 | 192.8 | cva 1
2831722 | 00 | 237.4 | 3113.5 | cva 1
2831731 | 00 | 7212.5 | 3345.6 | cva 1
2831746 | 00 | 1015.5 | 3046 | cva 1
2831748 | 00 | 93 | 3025.3 | cva 1
2831750 | 00 | 467 | 3025.3 | cva 1
2831758 | 00 | 149.277 | 3031.65 | cva 1
2831763 | 01 | 12.946 | 4067.8 | cva 1
2831776 | 00 | 1090.5 | 3171 | cvr 1
2831778 | 00 | 376.5 | 3150.3 | cvr 1
2831783 | 01 | 12.946 | 4267.8 | cvr 1
2831826 | 00 | 165.5 | 2971 | cvr 1
2832146 | 00 | 6111.45 | 3105.3 | cva 1
2832166 | 00 | 6161.45 | 3105.3 | cvr 1
2832215 | 00 | 6131.39 | 3349.5 | cva 1
2832513 | 00 | 145.8 | 3957.27 | cva 20
2832515 | 00 | 891.115 | 3061 | cva 20
2832517 | 00 | 127.385 | 3042.8 | cva 20
2832532 | 01 | 92.4166 | 4067.8 | cva 20
2832539 | 00 | 216.511 | 4107.27 | cvr 11
2832541 | 00 | 1041.12 | 3061 | cvr 11
2832543 | 00 | 127.385 | 3042.8 | cvr 11
2832558 | 01 | 17.4166 | 4267.8 | cvr 11
2832565 | 00 | 1698.91 | 413.5 | cvr 11
2832567 | 00 | 213.963 | 2118.71 | cvr 11
2832569 | 00 | 1392.47 | 2118.71 | cvr 11
2832577 | 00 | 12.946 | 392.8 | cvr 11
2832582 | 00 | 902.091 | 2136.91 | cvr 11
2832593 | 00 | 51.2107 | 4024.15 | cva 20
2832595 | 00 | 733.59 | 3285.41 | cva 20
2832597 | 00 | 147.95 | 3264.71 | cva 20
2832605 | 00 | 3207.05 | 3264.71 | cva 20
2832612 | 01 | 112.946 | 4067.8 | cva 20
2832621 | 00 | 297.95 | 3264.71 | cvr 11
2832623 | 00 | 976.09 | 3285.41 | cvr 11
2832627 | 00 | 3407.05 | 3264.71 | cvr 11
2832634 | 01 | 12.946 | 4267.8 | cvr 11
2832648 | 00 | 145.45 | 3264.71 | cva 20
2832650 | 00 | 776.09 | 3285.41 | cva 20
2832659 | 00 | 444.108 | 3262.91 | cva 20
2832668 | 01 | 112.946 | 4067.8 | cva 20
2832670 | 01 | 51.2107 | 4024.15 | cva 20
2832672 | 01 | 733.59 | 3285.41 | cva 20
2832674 | 01 | 145.45 | 3264.71 | cva 20
2832679 | 01 | 12.946 | 4067.8 | cva 20
2832695 | 00 | 2815.5 | 213.5 | cva 25
2832697 | 00 | 672.4 | 3035.3 | cva 25
2832699 | 00 | 2893.13 | 3035.3 | cva 25
2832707 | 00 | 12.946 | 192.8 | cva 25
2832712 | 00 | 54 | 3056 | cva 25; cvr 11
2832728 | 00 | 152.075 | 3278.13 | cvr 11
2832730 | 00 | 182.36 | 3387.8 | cvr 11
2832732 | 00 | 810.5 | 3408.5 | cvr 11
2832734 | 00 | 51.2107 | 4224.15 | cvr 11
2832743 | 00 | 444.08 | 3262.91 | cvr 11
2832760 | 01 | 12.946 | 4267.8 | cvr 11
2832762 | 01 | 853 | 3408.5 | cvr 11
2832764 | 01 | 182.36 | 3387.8 | cvr 11
2832766 | 01 | 168.075 | 3266.82 | cvr 11
2832771 | 01 | 112.946 | 4267.8 | cvr 11
2832843 | 00 | 6685.45 | 3262.91 | cva 20
2832969 | 00 | 2615.5 | 413.5 | cvr 16
2832971 | 00 | 622.359 | 3035.3 | cvr 16
2832973 | 00 | 2633.13 | 3035.3 | cvr 16
2832981 | 00 | 112.946 | 392.8 | cvr 16
2832986 | 00 | 54 | 3056 | cvr 16
2833004 | 00 | 51.2107 | 4022.88 | cva 20
2833006 | 00 | 733.59 | 3285.41 | cva 20
2833012 | 00 | 141.45 | 3262.91 | cva 20
2833021 | 00 | 662.373 | 3255.61 | cva 20
2833028 | 01 | 136.946 | 4066 | cva 20
2833040 | 00 | 182.36 | 3386 | cvr 11
2833042 | 00 | 853 | 3408.5 | cvr 11
2833050 | 00 | 148.075 | 3279.69 | cvr 11
2833059 | 00 | 402.427 | 3255.61 | cvr 11
2833066 | 01 | 36.946 | 4266 | cvr 11
2833082 | 00 | 51.2107 | 4024.15 | cva 20
2833084 | 00 | 733.59 | 3285.41 | cva 20
2833090 | 00 | 139.95 | 3264.71 | cva 20
2833099 | 00 | 6353 | 3255.61 | cva 20
2833106 | 01 | 107.946 | 4067.8 | cva 20
2833118 | 00 | 182.361 | 3387.8 | cvr 11
2833122 | 00 | 146.574 | 3282.02 | cvr 11
2833131 | 00 | 6353 | 3255.61 | cvr 11
2833138 | 01 | 853 | 3408.5 | cvr 11
2833161 | 00 | 2827.46 | 213.5 | cva 20
2833163 | 00 | 12.946 | 192.8 | cva 20
2833170 | 00 | 290.627 | 3046.11 | cva 20
2833179 | 00 | 6013 | 3255.61 | cva 20
2833192 | 00 | 2595 | 413.5 | cvr 11
2833194 | 00 | 297.95 | 3014.8 | cvr 11
2833200 | 00 | 12.946 | 392.8 | cvr 11
2833205 | 00 | 214.91 | 3035.5 | cvr 11
2833214 | 00 | 6112.95 | 3255.61 | cvr 11
2833227 | 00 | 36.946 | 191 | cva 20
2833232 | 00 | 2921.91 | 213.5 | cva 20
2833241 | 00 | 2833 | 213.5 | cva 20
2833243 | 00 | 1100.53 | 3052.8 | cva 20
2833249 | 00 | 112.946 | 192.8 | cva 20
2833254 | 00 | 176.91 | 3073.5 | cva 20
2833263 | 00 | 1938.85 | 3255.61 | cva 20
2833278 | 00 | 2633 | 413.5 | cvr 11
2833280 | 00 | 1200.53 | 3052.8 | cvr 11
2833286 | 00 | 12.946 | 392.8 | cvr 11
2833291 | 00 | 176.91 | 3073.5 | cvr 11
2833300 | 00 | 7228.15 | 3255.61 | cvr 11
2833313 | 00 | 2673 | 413.5 | cvr 11
2833315 | 00 | 1200.53 | 3092.8 | cvr 11
2833321 | 00 | 12.946 | 392.8 | cvr 11
2833326 | 00 | 136.91 | 3113.5 | cvr 11
2833335 | 00 | 8338 | 3251.51 | cvr 11
2833348 | 00 | 2873 | 213.5 | cva 20
2833350 | 00 | 1100.53 | 3092.8 | cva 20
2833356 | 00 | 112.946 | 192.8 | cva 20
2833361 | 00 | 136.91 | 3113.5 | cva 20
2833370 | 00 | 8388 | 3251.51 | cva 20
2833385 | 00 | 2688 | 413.5 | cvr 11
2833387 | 00 | 1200.55 | 3107.8 | cvr 11
2833393 | 00 | 12.946 | 392.8 | cvr 11
2833398 | 00 | 117.41 | 3128.5 | cvr 11
2833407 | 00 | 1291.6 | 3251.51 | cvr 11
2833420 | 00 | 2888 | 213.5 | cva 20
2833422 | 00 | 1100.55 | 3107.8 | cva 20
2833424 | 00 | 117.41 | 3128.5 | cva 20
2833432 | 00 | 112.946 | 192.8 | cva 20
2833445 | 00 | 532.35 | 4067.8 | cva 20
2833447 | 00 | 933 | 3128.5 | cva 20
2833449 | 00 | 1053.05 | 3107.8 | cva 20
2833451 | 00 | 117.41 | 3128.5 | cva 20
2833463 | 01 | 188.108 | 4067.8 | cva 20
2833473 | 00 | 382.35 | 4267.8 | cvr 11
2833475 | 00 | 1133 | 3128.5 | cvr 11
2833477 | 00 | 1153.05 | 3107.8 | cvr 11
2833487 | 00 | 117.41 | 3128.5 | cvr 11
2833496 | 00 | 13272.3 | 3251.51 | cvr 11
2833503 | 01 | 138.108 | 4267.8 | cvr 11
2833558 | 01 | 7.94599 | 4267.8 | cvr 11
2833681 | 00 | 13522.3 | 3251.51 | cva 20
2833701 | 00 | 1291.6 | 3251.51 | cva 20
2833976 | 00 | 6485.47 | 3262.91 | cvr 11
2849558 | F | 173.441 | -1316.8 | bra 3
2903021 | F | 9495.8 | -1316.8 | bra 3
2903399 | F | 84 | -1316.8 | bra 3
2903456 | F | 84 | -1546.8 | brr 1
2903528 | F | 13551.1 | -1316.8 | bra 2
2903530 | F | 13551.1 | -1546.8 | brr 3
2924611 | F | 9495.8 | -1546.8 | brr 1
2924619 | F | 658 | -1546.8 | brr 1
2924627 | F | 121.402 | -1546.8 | brr 1
2924674 | F | 658 | -1316.8 | bra 3
2924684 | F | 121.402 | -1316.8 | bra 3
2924911 | F | 3506.6 | -1316.8 | bra 3
2924932 | F | 3506.6 | -1546.8 | brr 1
2924940 | F | 5083.7 | -1546.8 | brr 1
2924948 | F | 210.631 | -1546.8 | brr 1
2924990 | F | 4582.69 | -1316.8 | bra 3
2925190 | F | 3208.16 | -1546.8 | brr 1
2925202 | F | 44546.9 | -1546.8 | brr 1
2925284 | F | 3208.16 | -1316.8 | bra 3
2925298 | F | 44546.9 | -1316.8 | bra 3

# IfcFlowSegment: Pipe Types:NLRS_50_PI_UN_Koper - soldeerverbinding_gen_ISR (592)
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipes
Classification: 5- (Uniformat)
Pset_DistributionFlowElementCommon - Reference: NLRS_50_PI_UN_Koper - soldeerverbinding_gen_ISR; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Name (Pipe Types:NLRS_50_PI_UN_Koper - soldeerverbinding_gen_ISR:...) | In | Roughness (mm) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
2277499 | 01 | 0.04572 | 62 | 4849.67 | kw 3
2277502 | 01 | 0.04572 | 62 | 4849.67 | kw 3
2277505 | 01 | 0.04572 | 445.5 | 4824.67 | kw 3
2277526 | 01 | 0.04572 | 62 | 4849.67 | kw 3
2277529 | 01 | 0.04572 | 62 | 4849.67 | kw 3
2277532 | 01 | 0.04572 | 422.5 | 4824.67 | kw 3
2277588 | 01 | 0.04572 | 6.5 | 4527.5 | kw 3
2277867 | 01 | 0.04572 | 6.5 | 4527.5 | kw 3
2277890 | 01 | 0.04572 | 10.5 | 4502.5 | kw 3
2277916 | 01 | 0.04572 | 1027.5 | 3473 | kw 3
2277925 | 01 | 0.04572 | 10.5 | 4502.5 | kw 3
2278569 | 01 | 0.04572 | 2.75 | 4908.92 | kw 3
2278574 | 01 | 0.04572 | 2.75 | 4908.92 | kw 3
2278578 | 01 | 0.04572 | 7.59531 | 4883.92 | kw 3
2278618 | 01 | 0.04572 | 1668.67 | 3243 | kw 3
2278636 | 01 | 0.04572 | 1479.67 | 3432 | kw 3
2278654 | 01 | 0.04572 | 65 | 4846.67 | kw 3
2278670 | 01 | 0.04572 | 53 | 4858.67 | kw 3
2278791 | 01 | 0.04572 | 138.5 | 4395.5 | kw 3
2279083 | 01 | 0.04572 | 1068.5 | 3465.5 | kw 3
2280770 | 00 | 0.04572 | 141 | 518 | kw 3
2281039 | 00 | 0.04572 | 1351 | -692 | kw 3
2282889 | 00 | 0.04572 | 1351 | -692 | kw 3
2283195 | 00 | 0.04572 | 1808.67 | -692 | kw 3
2283244 | 00 | 0.04572 | 62 | 1054.67 | kw 3
2283289 | 00 | 0.04572 | 62 | 1054.67 | kw 3
2283311 | 00 | 0.04572 | 1808.67 | -692 | kw 3
2283549 | 00 | 0.04572 | 1351 | -692 | kw 3
2283632 | 00 | 0.04572 | 1271 | -692 | kw 3
2283713 | 00 | 0.04572 | 1271 | -692 | kw 3
2283731 | 00 | 0.04572 | 1271 | -692 | kw 3
2283765 | 00 | 0.04572 | 1351 | -692 | kw 3
2284266 | 00 | 0.04572 | 340 | 1029.67 | kw 3
2284287 | 00 | 0.04572 | 1697.67 | -676 | kw 3
2284296 | 00 | 0.04572 | 60.015 | 1023.27 | kw 3
2284353 | 00 | 0.04572 | 62 | 1054.67 | kw 3
2284358 | 00 | 0.04572 | 62 | 1054.67 | kw 3
2284362 | 00 | 0.04572 | 422.338 | 1029.67 | kw 3
2284368 | 00 | 0.04572 | 1708.67 | -684 | kw 3
2284371 | 00 | 0.04572 | 425 | 1029.67 | kw 3
2284397 | 00 | 0.04572 | 207.5 | 451.5 | kw 3
2284439 | 00 | 0.04572 | 1351 | -692 | kw 3
2284468 | 00 | 0.04572 | 1227.67 | -684 | kw 3
2284773 | 00 | 0.04572 | 1351 | -692 | kw 3
2285303 | 00 | 0.04572 | 1808.67 | -692 | kw 3
2285905 | 00 | 0.04572 | 19.25 | 1083.92 | kw 3
2285910 | 00 | 0.04572 | 19.25 | 1083.92 | kw 3
2285914 | 00 | 0.04572 | 7.59531 | 1058.92 | kw 3
2286429 | 00 | 0.04572 | 1271 | -692 | kw 3
2287068 | 00 | 0.04572 | 1808.67 | -692 | kw 3
2287277 | 00 | 0.04572 | 62 | 1054.67 | kw 3
2287342 | 00 | 0.04572 | 151 | 965.671 | kw 53
2287372 | 00 | 0.04572 | 133 | 983.671 | kw 3
2287377 | 00 | 0.04572 | 119 | 997.671 | kw 3
2287382 | 00 | 0.04572 | 133 | 983.671 | kw 3
2287410 | 00 | 0.04572 | 151 | 965.671 | kw 55
2287802 | 00 | 0.04572 | 1141 | -692 | kw 3
2288565 | 00 | 0.04572 | 1141 | -692 | kw 3
2288597 | 00 | 0.04572 | 1141 | -692 | kw 3
2288641 | 00 | 0.04572 | 1141 | -692 | kw 3
2288769 | 00 | 0.04572 | 1751.92 | -698 | kw 3
2288778 | 00 | 0.04572 | 7.59531 | 1058.92 | kw 3
2288796 | 00 | 0.04572 | 19.25 | 1083.92 | kw 3
2288801 | 00 | 0.04572 | 19.25 | 1083.92 | kw 3
2288805 | 00 | 0.04572 | 7.59531 | 1058.92 | kw 3
2288811 | 00 | 0.04572 | 1751.92 | -698 | kw 3
2288814 | 00 | 0.04572 | 7.59531 | 1058.92 | kw 3
2288830 | 00 | 0.04572 | 19.25 | 1083.92 | kw 3
2288835 | 00 | 0.04572 | 19.25 | 1083.92 | kw 3
2288839 | 00 | 0.04572 | 7.59531 | 1058.92 | kw 3
2288845 | 00 | 0.04572 | 1737.92 | -684 | kw 3
2288848 | 00 | 0.04572 | 7.59531 | 1058.92 | kw 3
2288870 | 00 | 0.04572 | 1351 | -692 | kw 3
2288977 | 00 | 0.04572 | 443 | 581.671 | kw 3
2288985 | 00 | 0.04572 | 39.5225 | 545.221 | kw 3
2288996 | 00 | 0.04572 | 71.3289 | 587.671 | kw 3
2289334 | 00 | 0.04572 | 317.51 | 1029.67 | kw 3
2289352 | 00 | 0.04572 | 48 | 1068.67 | kw 3
2289644 | 00 | 0.04572 | 895 | 958.671 | kw 3
2289675 | 00 | 0.04572 | 321.783 | 955.221 | kw 3
2289687 | 00 | 0.04572 | 1637.67 | -684 | kw 3
2289696 | 00 | 0.04572 | 549.217 | 958.671 | kw 3
2289850 | 01 | 0.04572 | 36 | 4842.92 | kw 3
2289859 | 01 | 0.04572 | 7.59531 | 4883.92 | kw 3
2289889 | 01 | 0.04572 | 2.75 | 4908.92 | kw 3
2289894 | 01 | 0.04572 | 2.75 | 4908.92 | kw 3
2289898 | 01 | 0.04572 | 7.59531 | 4883.92 | kw 3
2289904 | 01 | 0.04572 | 36 | 4842.92 | kw 3
2289907 | 01 | 0.04572 | 7.59531 | 4883.92 | kw 3
2289921 | 01 | 0.04572 | 2.75 | 4908.92 | kw 3
2289926 | 01 | 0.04572 | 2.75 | 4908.92 | kw 3
2289930 | 01 | 0.04572 | 7.59531 | 4883.92 | kw 3
2289936 | 01 | 0.04572 | 36 | 4842.92 | kw 3
2289939 | 01 | 0.04572 | 7.59531 | 4883.92 | kw 3
2289953 | 01 | 0.04572 | 2.75 | 4908.92 | kw 3
2289958 | 01 | 0.04572 | 2.75 | 4908.92 | kw 3
2289962 | 01 | 0.04572 | 7.59531 | 4883.92 | kw 3
2289968 | 01 | 0.04572 | 36 | 4842.92 | kw 3
2289971 | 01 | 0.04572 | 7.59531 | 4883.92 | kw 3
2289983 | 01 | 0.04572 | 2.75 | 4908.92 | kw 3
2289988 | 01 | 0.04572 | 2.75 | 4908.92 | kw 3
2289992 | 01 | 0.04572 | 7.59531 | 4883.92 | kw 3
2289998 | 01 | 0.04572 | 22 | 4856.92 | kw 3
2290001 | 01 | 0.04572 | 7.59531 | 4883.92 | kw 3
2290299 | 01 | 0.04572 | 921 | 4820.47 | kw 3
2290438 | 01 | 0.04572 | 314.294 | 4820.47 | kw 3
2290464 | 01 | 0.04572 | 921 | 4820.47 | kw 3
2290488 | 01 | 0.04572 | 538.536 | 4820.47 | kw 3
2290504 | 01 | 0.04572 | 1326.92 | 3489 | kw 3
2290513 | 01 | 0.04572 | 304.464 | 4820.47 | kw 3
2290852 | 01 | 0.04572 | 422.5 | 4824.67 | kw 3
2291045 | 00 | 0.04572 | 84.8746 | 3437.05 | kw 3
2291055 | 00 | 0.04572 | 17.9143 | 3437.05 | kw 3
2291064 | 01 | 0.04572 | 1346.17 | 3473.5 | kw 3
2291080 | 00 | 0.04572 | 2454.47 | 3440.5 | kw 3
2291090 | 00 | 0.04572 | 193.69 | 3440.5 | kw 3
2291896 | 01 | 0.04572 | 626.5 | 4370.5 | kw 3
2291965 | 01 | 0.04572 | 324 | 4370.5 | kw 3
2292029 | 01 | 0.04572 | 884 | 3475.5 | kw 3
2292366 | 01 | 0.04572 | 148 | 4726.83 | kw 3
2292378 | 01 | 0.04572 | 1266 | 3455.53 | kw 3
2292388 | 01 | 0.04572 | 52.6254 | 3417.08 | kw 3
2292436 | 01 | 0.04572 | 96.8629 | 4833.67 | kw 3
2292562 | 01 | 0.04572 | 138.5 | 4395.5 | kw 3
2292566 | 01 | 0.04572 | 626.5 | 4370.5 | kw 3
2292570 | 01 | 0.04572 | 324 | 4370.5 | kw 3
2292574 | 01 | 0.04572 | 884 | 3475.5 | kw 3
2473693 | 00 | 0.04572 | 1271 | -692 | kw 3
2474740 | 00 | 0.04572 | 1271 | -692 | kw 3
2474768 | 00 | 0.04572 | 1271 | -692 | kw 3
2479006 | 01 | 0.04572 | 304.8 | 4194.2 | kw 15
2479185 | 01 | 0.04572 | 239.8 | 4234.2 | kw 3
2506289 | 00 | 0.04572 | 84.0162 | 273.75 | kw 3
2506510 | 00 | 0.04572 | 849 | -660 | kw 3
2508278 | 00 | 0.04572 | 434.8 | 147.2 | kw 3
2508321 | 00 | 0.04572 | 41.2893 | 491.5 | ww 2
2508331 | 00 |  | 88 | 516 | ww 2
2508339 | 00 | 0.04572 | 832.613 | 491.5 | ww 2
2508372 | 00 | 0.04572 | 41.2893 | 491.5 | ww 2
2508384 | 00 |  | 88 | 516 | ww 2
2508557 | 00 | 0.04572 | 742.613 | 491.5 | ww 2
2508562 | 00 | 0.04572 | 101 | 477 | ww 2
2508600 | 00 | 0.04572 | 172.093 | 593 | kw 3
2508632 | 00 | 0.04572 | 1274 | -692 | kw 3
2508891 | 00 | 0.04572 | 58.8629 | 591.5 | ww 2
2509226 | 00 | 0.04572 | 78 | 511 | ww 2
2509382 | 00 | 0.04572 | 92.6101 | 684.251 | ww 2
2509394 | 00 | 0.04572 | 67.3112 | 611 | ww 2
2509425 | 00 | 0.04572 | 2590.3 | 767.696 | ww 2
2509522 | 00 | 0.04572 | 1461 | 3371.5 | ww 2
2509530 | 00 | 0.04572 | 6594.87 | 3371.5 | ww 2
2509594 | 00 | 0.04572 | 867.266 | 3371.5 | ww 2
2509631 | 00 | 0.04572 | 2728 | 630 | ww 2
2509910 | 00 | 0.04572 | 1487 | 3011.5 | ww 2
2509919 | 00 | 0.04572 | 2252 | 3371.5 | ww 2
2510126 | 00 | 0.04572 | 2576 | 422 | ww 2
2510136 | 00 | 0.04572 | 546.248 | 391.5 | ww 2
2510172 | 00 | 0.04572 | 157 | 422 | ww 2
2510270 | 00 | 0.04572 | 1707 | 3371.5 | ww 2
2510290 | 00 | 0.04572 | 316 | 3042 | ww 2
2511643 | 00 | 0.04572 | 64.5 | 591.5 | ww 1
2511655 | 00 |  | 132 | 452 | ww 1
2511678 | 00 | 0.04572 | 2456 | 522 | ww 1
2511848 | 00 | 0.04572 | 68 | 511 | ww 1
2511863 | 00 | 0.04572 | 16 | 480.5 | ww 1
2511910 | 00 | 0.04572 | 56 | 480.5 | ww 1
2511921 | 00 | 0.04572 | 78 | 511 | ww 1
2511924 | 00 | 0.04572 | 43 | 591.5 | ww 1
2512003 | 00 | 0.04572 | 1317 | 2991.5 | ww 1
2512011 | 00 | 0.04572 | 816 | 2991.5 | ww 1
2512036 | 00 | 0.04572 | 982 | 2991.5 | ww 1
2512047 | 00 | 0.04572 | 877.5 | 2991.5 | ww 1
2512073 | 00 | 0.04572 | 2582.8 | 395.2 | ww 1
2512101 | 00 | 0.04572 | 2582.8 | 395.2 | ww 1
2512285 | F | 0.04572 | 642.933 | -717 | kw 3
2512949 | 00 | 0.04572 | 104 | 493 | ww 3
2512963 | 00 | 0.04572 | 32 | 452 | ww 3
2513032 | 00 | 0.04572 | 79.5 | 493 | ww 3
2513377 | 00 | 0.04572 | 71 | 518 | ww 3
2513406 | 00 | 0.04572 | 1271 | -692 | kw 3
2514044 | 00 | 0.04572 | 1095.5 | -623 | ww 3
2514053 | 00 | 0.04572 | 184.5 | 493 | ww 3
2514100 | 00 | 0.04572 | 1202 | -623 | ww 3
2514260 | 00 | 0.04572 | 3114 | -648 | ww 3
2514363 | F | 0.04572 | 4476.5 | -648 | ww 3
2515223 | 01 | 0.04572 | 1102 | 3372 | ww 5
2515882 | 00 | 0.04572 | 44 | 593 | kw 3
2515894 | 00 | 0.04572 | 107 | 477 | kw 3
2515912 | 00 | 0.04572 | 1274 | -692 | kw 3
2515976 | 00 | 0.04572 | 105 | 477 | ww 5
2515982 | 00 | 0.04572 | 163.548 | 593 | ww 5
2516162 | 00 | 0.04572 | 2352 | 976 | ww 5
2516170 | 00 | 0.04572 | 283.994 | 3341.5 | ww 5
2516527 | 00 | 0.04572 | 465 | 3341.5 | ww 5
2516645 | 00 | 0.04572 | 97 | 482 | ww 5
2516660 | 00 | 0.04572 | 28.033 | 457 | ww 5
2516735 | 00 | 0.04572 | 432.5 | 457 | ww 5
2516963 | 00 | 0.04572 | 109 | 482 | ww 5
2517020 | F | 0.04572 | 3366 | -730.25 | kw 3
2517028 | F | 0.04572 | 9126.75 | -726.75 | kw 3
2517164 | F | 0.04572 | 989.843 | -726.75 | kw 3
2517180 | F | 0.04572 | 642.933 | -717 | kw 3
2517220 | F | 0.04572 | 797.933 | -717 | kw 3
2517229 | F | 0.04572 | 663.657 | -726.75 | kw 3
2517315 | F | 0.04572 | 642.933 | -717 | kw 3
2517433 | F | 0.04572 | 282.995 | -726.75 | kw 3
2517489 | F | 0.04572 | 7876.59 | -720.45 | kw 3
2517531 | F | 0.04572 | 205.005 | -717 | kw 3
2517539 | F | 0.04572 | 184 | -717 | kw 3
2517554 | F | 0.04572 | 361.885 | -717 | kw 3
2517567 | F | 0.04572 | 3085.95 | -720.45 | kw 3
2517590 | F | 0.04572 | 506.078 | -717 | kw 3
2517601 | F | 0.04572 | 53 | -720.45 | kw 3
2517619 | F | 0.04572 | 2058.66 | -723.4 | kw 3
2517649 | F | 0.04572 | 922 | -720.45 | kw 3
2517712 | F | 0.04572 | 2006.57 | -723.4 | kw 3
2517721 | F | 0.04572 | 711.912 | -726.75 | kw 3
2517788 | F | 0.04572 | 3765.93 | -726.75 | kw 3
2517980 | F | 0.04572 | 459.567 | -720.45 | kw 3
2517989 | F | 0.04572 | 2795.1 | -723.4 | kw 3
2518019 | F | 0.04572 | 458.903 | -717 | kw 3
2518028 | F | 0.04572 | 1526 | -720.45 | kw 3
2518050 | F | 0.04572 | 448.903 | -717 | kw 3
2518074 | F | 0.04572 | 1703.66 | -723.4 | kw 3
2518228 | F | 0.04572 | 62 | -720.45 | kw 3
2518297 | F | 0.04572 | 201.51 | -720.45 | kw 3
2518308 | F | 0.04572 | 61.9239 | -723.4 | kw 3
2518390 | 00 | 0.04572 | 214 | 902.671 | kw 3
2518601 | 00 | 0.04572 | 148 | 782.827 | kw 3
2518613 | 00 | 0.04572 | 1469.53 | -692 | kw 3
2518642 | F | 0.04572 | 2144.52 | -717 | kw 3
2518668 | F | 0.04572 | 1382.5 | -723.4 | kw 3
2518727 | F | 0.04572 | 2393.07 | -717 | kw 3
2518749 | F | 0.04572 | 2261 | -720.45 | kw 3
2518794 | F | 0.04572 | 496.433 | -720.45 | kw 3
2518812 | F | 0.04572 | 25.0482 | -717 | kw 3
2518819 | F | 0.04572 | 355 | -717 | kw 3
2518839 | F | 0.04572 | 3362.25 | -720.45 | kw 3
2518907 | F | 0.04572 | 483.433 | -717 | kw 3
2518931 | F | 0.04572 | 1075 | -717 | kw 3
2518951 | F | 0.04572 | 1358.07 | -717 | kw 3
2518967 | F | 0.04572 | 731.048 | -720.45 | kw 3
2519006 | F | 0.04572 | 7106.93 | -717 | kw 3
2519028 | F | 0.04572 | 4657.2 | -720.45 | kw 3
2519095 | 00 | 0.04572 | 4119.5 | -684 | kw 3
2519102 | 00 | 0.04572 | 56.2025 | 3440.5 | kw 3
2519238 | F | 0.04572 | 484.5 | -720.45 | kw 3
2519497 | F | 0.04572 | 116 | -720.45 | kw 3
2523913 | 00 | 0.04572 | 1351 | -692 | kw 3
2523953 | F | 0.04572 | 2815.16 | -717 | kw 3
2523962 | F | 0.04572 | 2118.34 | -723.4 | kw 3
2524311 | F | 0.04572 | 3040.98 | -720.45 | kw 3
2524319 | F | 0.04572 | 796.123 | -720.45 | kw 3
2524363 | F | 0.04572 | 1356.62 | -717 | kw 3
2524383 | F | 0.04572 | 1368.62 | -720.45 | kw 3
2524399 | F | 0.04572 | 1247.83 | -717 | kw 3
2524409 | F | 0.04572 | 491.674 | -720.45 | kw 3
2524453 | F | 0.04572 | 116 | -717 | kw 3
2524504 | F | 0.04572 | 5066.74 | -720.45 | kw 3
2524513 | F | 0.04572 | 8709.16 | -720.45 | kw 3
2524535 | F | 0.04572 | 170.164 | -717 | kw 3
2524551 | F | 0.04572 | 107.5 | -717 | kw 3
2524587 | F | 0.04572 | 1140 | -717 | kw 3
2524613 | F | 0.04572 | 1732.24 | -717 | kw 3
2524636 | F | 0.04572 | 3118.5 | -717 | kw 3
2524656 | F | 0.04572 | 1718.24 | -717 | kw 3
2524666 | 00 | 0.04572 | 1143 | -694 | kw 3
2524687 | F | 0.04572 | 609.255 | -717 | kw 3
2524721 | F | 0.04572 | 4227.66 | -720.45 | kw 3
2524812 | F | 0.04572 | 10142.7 | -720.45 | kw 3
2524868 | F | 0.04572 | 328.164 | -717 | kw 3
2524884 | F | 0.04572 | 727.356 | -717 | kw 3
2524900 | F | 0.04572 | 727.356 | -717 | kw 3
2524916 | F | 0.04572 | 564.644 | -720.45 | kw 3
2524941 | F | 0.04572 | 4788.14 | -723.4 | kw 3
2524955 | F | 0.04572 | 4907.5 | -723.4 | kw 3
2524993 | F | 0.04572 | 1802.5 | -723.4 | kw 3
2529500 | F | 0.04572 | 708.75 | -717 | kw 3
2529801 | F | 0.04572 | 3904.71 | -726.75 | kw 3
2529811 | F | 0.04572 | 5494.61 | -726.75 | kw 3
2529911 | F | 0.04572 | 12470.2 | -726.75 | kw 3
2535292 | 00 | 0.04572 | 14.5 | 273.75 | kw 3
2535384 | 00 | 0.04572 | 2730 | -426.25 | kw 3
2535397 | 00 | 0.04572 | 570 | -335 | kw 3
2537158 | 01 | 0.04572 | 1024 | 3300 | kw BSH
2537166 | 01 | 0.04572 | 140 | 3263.55 | kw BSH
2537260 | 00 | 0.04572 | 1065 | 3263.55 | kw BSH
2537271 | 00 | 0.04572 | 204.244 | 3263.55 | kw BSH
2537373 | 00 | 0.04572 | 3992 | -744 | kw BSH
2537381 | F | 0.04572 | 941.9 | -780.45 | kw BSH
2537548 | 01 | 0.04572 | 844 | 3480 | kw BSH
2537689 | 01 | 0.04572 | 1468 | 3443.55 | kw BSH
2537741 | 00 | 0.04572 | 912.157 | 3443.55 | kw BSH
2538162 | F | 0.04572 | 3421.59 | -780.45 | kw BSH
2538171 | 00 | 0.04572 | 4172 | -744 | kw BSH
2538227 | 00 | 0.04572 | 1193 | -744 | kw BSH
2538552 | F | 0.04572 | 2811.41 | -780.45 | kw BSH
2538610 | 00 | 0.04572 | 1193 | -744 | kw BSH
2538614 | F | 0.04572 | 967.4 | -780.45 | kw BSH
2538670 | 00 | 0.04572 | 1193 | -744 | kw BSH
2538737 | F | 0.04572 | 3600.69 | -783.4 | kw BSH
2538762 | F | 0.04572 | 1465.59 | -783.4 | kw BSH
2538846 | F | 0.04572 | 5620.41 | -780.45 | kw BSH
2538986 | F | 0.04572 | 17227.5 | -786.75 | kw BSH
2538995 | F | 0.04572 | 2172.91 | -780.45 | kw BSH
2539043 | F | 0.04572 | 7599 | -783.4 | kw BSH
2539065 | F | 0.04572 | 1565 | -780.45 | kw BSH
2539144 | F | 0.04572 | 11053.5 | -783.4 | kw BSH
2545588 | 01 | 0.04572 | 576 | 3430.53 | kw 3
2545662 | 00 | 0.04572 | 1435.87 | 3430.53 | kw 3
2545752 | 00 | 0.04572 | 4085.53 | -684 | kw 3
2545790 | F | 0.04572 | 285.966 | -720.45 | kw 3
2545826 | F | 0.04572 | 6905.84 | -723.4 | kw 3
2545893 | F | 0.04572 | 401.389 | -717 | kw 3
2545910 | 00 | 0.04572 | 4123.53 | -698 | kw 3
2545938 | F | 0.04572 | 799.856 | -720.45 | kw 3
2546408 | 00 | 0.04572 | 1089.84 | 3450.5 | kw 3
2546619 | 00 | 0.04572 | 1301.5 | 3450.5 | kw 3
2546644 | 00 | 0.04572 | 2979 | 460.5 | kw 3
2546933 | 00 | 0.04572 | 83 | 435.5 | kw 3
2546948 | 00 | 0.04572 | 1125.5 | -692 | kw 3
2547765 | F | 0.04572 | 6583.49 | -723.4 | kw 3
2548027 | F | 0.04572 | 703.02 | -720.45 | kw 3
2548055 | F | 0.04572 | 1231.13 | -717 | kw 3
2553433 | 01 | 0.04572 | 1876 | 3341.5 | ww 5
2553632 | 00 | 0.04572 | 965 | 3427.5 | ww 5
2553642 | 00 | 0.04572 | 10355.5 | 3427.5 | ww 5
2553790 | 00 | 0.04572 | 651 | 3427.5 | ww 5
2553798 | 00 | 0.04572 | 107.622 | 3348.94 | ww 5
2554008 | 00 | 0.04572 | 831 | 3341.5 | ww 5
2554083 | 00 | 0.04572 | 107.622 | 3348.94 | ww 5
2555470 | 00 | 0.04572 | 1280 | -692 | kw 3
2555501 | 00 | 0.04572 | 1280 | -692 | kw 3
2555524 | F | 0.04572 | 303.067 | -717 | kw 3
2555540 | F | 0.04572 | 1353.07 | -717 | kw 3
2555635 | F | 0.04572 | 15441.5 | -726.75 | kw 3
2555649 | F | 0.04572 | 113 | -726.75 | kw 3
2566097 | 01 | 0.04572 | 1042 | 3432 | kw 3
2567478 | 01 | 0.04572 | 84 | 4400 | ww 12
2567595 | 01 | 0.04572 | 26 | 4448 | kw 3
2573419 | 01 | 0.04572 | 67 | 4352 | kw 3
2573622 | 01 | 0.04572 | 34 | 4430 | kw 3
2573884 | 01 | 0.04572 | 12 | 4352 | ww 12
2573899 | 01 | 0.04572 | 313.617 | 4375 | ww 12
2574009 | 01 | 0.04572 | 81.2821 | 4375 | ww 12
2574056 | 01 | 0.04572 | 189.617 | 4430 | kw 3
2574131 | 01 | 0.04572 | 24.6396 | 4430 | kw 3
2574206 | 01 | 0.04572 | 1240 | 3184.98 | kw 3
2574458 | 01 | 0.04572 | 141.5 | 3407 | kw 3
2574525 | 01 | 0.04572 | 4088 | -692 | kw 3
2574533 | F | 0.04572 | 2762.5 | -717 | kw 3
2574638 | 00 | 0.04572 | 692.894 | 3148.55 | kw 3
2574656 | 00 | 0.04572 | 3817 | -684 | kw 3
2574965 | F | 0.04572 | 4485.1 | -720.45 | kw 3
2574975 | F | 0.04572 | 3151.14 | -720.45 | kw 3
2574990 | F | 0.04572 | 495.729 | -720.45 | kw 3
2674948 | F | 0.04572 | 2012.36 | -720.45 | kw 3
2674961 | F | 0.04572 | 277.452 | -723.4 | kw 3
2675027 | F | 0.04572 | 707.338 | -717 | kw 3
2675036 | F | 0.04572 | 196.664 | -723.4 | kw 3
2675052 | F | 0.04572 | 3731.93 | -717 | kw 3
2675065 | F | 0.04572 | 443.005 | -726.75 | kw 3
2710340 | 00 | 0.04572 | 2266 | 3184.55 | gkwa 3
2716932 | 00 | 0.04572 | 2605 | 3409.55 | gkwr 2
2726415 | 00 | 0.04572 | 29.1269 | 3184.55 | gkwa 3
2726470 | 00 | 0.04572 | 29.1269 | 3409.55 | cvr 4; gkwr 2
2727907 | 00 | 0.04572 | 921.054 | 3184.55 | gkwa 3
2727931 | 00 | 0.04572 | 85.7631 | 3166 | gkwa 3
2728033 | 00 | 0.04572 | 254.335 | 3409.55 | gkwr 2
2728045 | 00 | 0.04572 | 164 | 3230 | gkwr 2
2728085 | 00 | 0.04572 | 1062.47 | 3409.55 | gkwr 2
2728120 | 00 | 0.04572 | 182 | 3184.55 | gkwa 3
2728160 | 00 | 0.04572 | 179.579 | 3184.55 | gkwa 3
2728175 | 00 | 0.04572 | 79.618 | 3184.55 | gkwa 3
2736257 | 00 | 0.04572 | 665.5 | 3413.55 | ww 10
2742039 | 00 | 0.04572 | 420 | 2617.68 | ww 10
2742041 | 00 | 0.04572 | 959.373 | 2918.68 | ww 10
2742048 | 00 | 0.04572 | 531 | 2080 | ww 10
2742253 | 00 | 0.04572 | 442.873 | 2955.13 | ww 10
2742263 | 00 | 0.04572 | 1239.91 | 2918.68 | ww 10
2742360 | 00 | 0.04572 | 588 | 2289.55 | kw 3
2742362 | 00 | 0.04572 | 2958 | -684 | kw 3
2742366 | F | 0.04572 | 2326.16 | -720.45 | kw 3
2742368 | 00 | 0.04572 | 194 | 2080 | kw 3
2742469 | F | 0.04572 | 470 | -717 | kw 3
2776576 | 01 | 0.04572 | 16.5 | 7358.55 | ww 10
2776582 | 01 | 0.04572 | 291.5 | 7358.55 | kw 3
2776843 | 00 | 0.04572 | 64 | 7384 | ww 13
2776847 | 00 | 0.04572 | 1092 | 6281 | ww 13
2776851 | 00 | 0.04572 | 1092 | 6281 | ww 14
2776853 | 00 | 0.04572 | 114 | 7384 | ww 14
2776859 | 00 | 0.04572 | 1092 | 6281 | ww 15
2776865 | 00 | 0.04572 | 2164 | 7384 | ww 15
2777171 | 01 | 0.04572 | 1689 | 7384 | ww 14
2777179 | 01 | 0.04572 | 1532.84 | 7384 | ww 14
2777207 | 01 | 0.04572 | 739 | 7384 | ww 13
2777215 | 01 | 0.04572 | 1538.84 | 7384 | ww 13
2777281 | 01 | 0.04572 | 441.837 | 7384 | ww 15
2777446 | 01 | 0.04572 | 304.69 | 7384 | ww 13
2777572 | 01 | 0.04572 | 105.31 | 7362 | ww 13
2777573 | 01 | 0.04572 | 17.1127 | 7369 | ww 13
2777614 | 01 | 0.04572 | 354.69 | 7384 | ww 14
2777616 | 01 | 0.04572 | 105.31 | 7362 | ww 14
2777617 | 01 | 0.04572 | 17.1127 | 7369 | ww 14
2777634 | 01 | 0.04572 | 404.69 | 7384 | ww 15
2777636 | 01 | 0.04572 | 105.31 | 7362 | ww 15
2777637 | 01 | 0.04572 | 17.1127 | 7369 | ww 15
2777654 | 01 | 0.04572 | 404.69 | 7384 | ww 16
2777656 | 01 | 0.04572 | 105.31 | 7362 | ww 16
2777657 | 01 | 0.04572 | 17.1127 | 7369 | ww 16
2777676 | 01 | 0.04572 | 354.69 | 7384 | ww 18
2777678 | 01 | 0.04572 | 105.31 | 7362 | ww 18
2777679 | 01 | 0.04572 | 17.1127 | 7369 | ww 18
2777696 | 01 | 0.04572 | 304.69 | 7384 | ww 17
2777698 | 01 | 0.04572 | 105.31 | 7362 | ww 17
2777699 | 01 | 0.04572 | 17.1127 | 7369 | ww 17
2778134 | 00 | 0.04572 | 64 | 7384 | ww 17
2778136 | 00 | 0.04572 | 1092 | 6281 | ww 17
2778138 | 00 | 0.04572 | 1092 | 6281 | ww 18
2778140 | 00 | 0.04572 | 114 | 7384 | ww 18
2778142 | 00 | 0.04572 | 1092 | 6281 | ww 16
2778144 | 00 | 0.04572 | 2164 | 7384 | ww 16
2778156 | 01 | 0.04572 | 1689 | 7384 | ww 18
2778158 | 01 | 0.04572 | 1538.84 | 7384 | ww 18
2778162 | 01 | 0.04572 | 739 | 7384 | ww 17
2778164 | 01 | 0.04572 | 1544.84 | 7384 | ww 17
2778168 | 01 | 0.04572 | 442.163 | 7384 | ww 16
2778283 | 01 | 0.04572 | 31.5 | 7358.55 | ww 10
2778293 | 00 | 0.04572 | 64 | 7384 | ww 26
2778295 | 00 | 0.04572 | 1092 | 6281 | ww 26
2778297 | 00 | 0.04572 | 1092 | 6281 | ww 27
2778299 | 00 | 0.04572 | 114 | 7384 | ww 27
2778301 | 00 | 0.04572 | 1092 | 6281 | ww 28
2778303 | 00 | 0.04572 | 114 | 7384 | ww 28
2778315 | 01 | 0.04572 | 1689 | 7384 | ww 27
2778317 | 01 | 0.04572 | 1532.84 | 7384 | ww 27
2778319 | 01 | 0.04572 | 739 | 7384 | ww 26
2778321 | 01 | 0.04572 | 1538.84 | 7384 | ww 26
2778325 | 01 | 0.04572 | 436.163 | 7384 | ww 28
2778327 | 01 | 0.04572 | 304.69 | 7384 | ww 26
2778329 | 01 | 0.04572 | 105.31 | 7362 | ww 26
2778330 | 01 | 0.04572 | 17.1127 | 7369 | ww 26
2778333 | 01 | 0.04572 | 354.69 | 7384 | ww 27
2778335 | 01 | 0.04572 | 105.31 | 7362 | ww 27
2778336 | 01 | 0.04572 | 17.1127 | 7369 | ww 27
2778341 | 01 | 0.04572 | 404.69 | 7384 | ww 28
2778343 | 01 | 0.04572 | 105.31 | 7362 | ww 28
2778344 | 01 | 0.04572 | 17.1127 | 7369 | ww 28
2778349 | 01 | 0.04572 | 404.69 | 7384 | ww 29
2778351 | 01 | 0.04572 | 105.31 | 7362 | ww 29
2778352 | 01 | 0.04572 | 17.1127 | 7369 | ww 29
2778357 | 01 | 0.04572 | 354.69 | 7384 | ww 31
2778359 | 01 | 0.04572 | 105.31 | 7362 | ww 31
2778360 | 01 | 0.04572 | 17.1127 | 7369 | ww 31
2778365 | 01 | 0.04572 | 304.69 | 7384 | ww 30
2778367 | 01 | 0.04572 | 105.31 | 7362 | ww 30
2778368 | 01 | 0.04572 | 17.1127 | 7369 | ww 30
2778395 | 00 | 0.04572 | 64 | 7384 | ww 30
2778397 | 00 | 0.04572 | 1092 | 6281 | ww 30
2778399 | 00 | 0.04572 | 1092 | 6281 | ww 31
2778401 | 00 | 0.04572 | 114 | 7384 | ww 31
2778403 | 00 | 0.04572 | 1092 | 6281 | ww 29
2778405 | 00 | 0.04572 | 114 | 7384 | ww 29
2778417 | 01 | 0.04572 | 1689 | 7384 | ww 31
2778419 | 01 | 0.04572 | 1538.84 | 7384 | ww 31
2778421 | 01 | 0.04572 | 739 | 7384 | ww 30
2778423 | 01 | 0.04572 | 1544.84 | 7384 | ww 30
2778427 | 01 | 0.04572 | 447.837 | 7384 | ww 29
2778925 | 01 | 0.04572 | 3611.33 | 7358.55 | kw 3
2778939 | 01 | 0.04572 | 305.5 | 7358.55 | kw 3
2779104 | 01 | 0.04572 | 286.139 | 7358.55 | kw 3
2779370 | 01 | 0.04572 | 1375.14 | 3453.53 | kw 3
2779389 | 01 | 0.04572 | 2490.33 | 4852.67 | kw 3
2779397 | 01 | 0.04572 | 771.863 | 7358.55 | kw 3
2779621 | 01 | 0.04572 | 63 | 7280 | ww 10
2779654 | 01 | 0.04572 | 447 | 7243.55 | ww 10
2779666 | 01 | 0.04572 | 179.747 | 7251.56 | ww 10
2779678 | 01 | 0.04572 | 2666 | 7380.55 | ww 10
2779769 | 01 | 0.04572 | 179.747 | 7251.56 | ww 10
2779781 | 01 | 0.04572 | 409 | 7243.55 | ww 10
2779836 | 01 | 0.04572 | 82 | 7265 | ww 10
2779882 | 01 | 0.04572 | 178.326 | 7243.55 | ww 10
2779957 | 01 | 0.04572 | 3524.5 | 7243.55 | ww 10
2779978 | 01 | 0.04572 | 4028 | 3200 | ww 10
2780077 | 01 | 0.04572 | 565.304 | 3163.55 | ww 10
2780199 | 01 | 0.04572 | 198 | 3200 | ww 10
2784745 | 01 | 0.04572 | 84 | 7247 | ww 10
2785164 | 01 | 0.04572 | 139.856 | 7255.41 | ww 10
2785214 | 01 | 0.04572 | 6585 | 7356.5 | ww 10
2785337 | 01 | 0.04572 | 1544.59 | 7356.5 | ww 10
2785347 | 01 | 0.04572 | 232.5 | 7356.5 | ww 10
2785385 | 01 | 0.04572 | 2782 | 4563.5 | ww 10
2785424 | 01 | 0.04572 | 222 | 7356.5 | ww 10
2785442 | 01 | 0.04572 | 1682.5 | 7356.5 | ww 10
2785450 | 01 | 0.04572 | 104.591 | 7356.5 | ww 10
2785472 | 01 | 0.04572 | 2782 | 4563.5 | ww 10
2785864 | 01 | 0.04572 | 5 | 4352 | kw 3
2785866 | 01 | 0.04572 | 12 | 4352 | ww 4
2786134 | 01 | 0.04572 | 74 | 4400 | ww 4
2786170 | 01 | 0.04572 | 164 | 4375 | ww 4
2786204 | 01 | 0.04572 | 948 | 3418 | kw 3
2786228 | 01 | 0.04572 | 1024 | 3393 | kw 3
2786247 | 01 | 0.04572 | 164 | 4368 | kw 3
2786266 | 01 | 0.04572 | 63 | 4368 | kw 3
2786399 | 01 | 0.04572 | 90 | 4384 | kw 3
2786460 | 00 | 0.04572 | 808.804 | 3393 | kw 3
2786708 | 00 | 0.04572 | 1104.01 | 3393 | kw 3
2786873 | 00 | 0.04572 | 336 | 3389.55 | kw 3
2786881 | 00 | 0.04572 | 688 | 3389.55 | kw 3
2787034 | 00 | 0.04572 | 598 | 2776 | kw 3
2787178 | 00 | 0.04572 | 588 | 2739.55 | kw 3
2787196 | 00 | 0.04572 | 235.196 | 2739.55 | kw 3
2787203 | 00 | 0.04572 | 1675.33 | 1048.67 | kw 3
2787206 | 00 | 0.04572 | 553.49 | 1026.22 | kw 3
2787524 | 01 | 0.04572 | 974.329 | 3388.67 | kw 3
2787533 | 01 | 0.04572 | 445.5 | 4824.67 | kw 3
2787822 | 00 | 0.04572 | 847.272 | 3349.27 | kw 3
2787873 | 00 | 0.04572 | 2361 | 3349.27 | kw 3
2787959 | 00 | 0.04572 | 2277 | 1051.67 | kw 3
2787990 | 00 | 0.04572 | 249.985 | 1029.67 | kw 3
2788093 | 01 | 0.04572 | 828.125 | 4368 | kw 3
2788103 | 01 | 0.04572 | 168 | 4391 | kw 3
2788109 | 01 | 0.04572 | 957.738 | 4368 | kw 3
2788265 | 01 | 0.04572 | 415.671 | 4387 | kw 3
2788672 | 00 | 0.04572 | 22 | 3355.67 | kw 3
2788680 | 00 | 0.04572 | 56.3289 | 3380.67 | kw 3
2788690 | 00 | 0.04572 | 822 | 3448 | kw 3
2788823 | 01 | 0.04572 | 1061 | 3473 | kw 3
2788944 | 00 | 0.04572 | 1010 | 3448 | kw 3
2788952 | 00 | 0.04572 | 2713.49 | 3441.6 | kw 3
2788983 | 00 | 0.04572 | 956.464 | 3441.6 | kw 3
2788997 | 00 | 0.04572 | 1749.55 | 3441.6 | kw 3
2789494 | 01 | 0.04572 | 185 | 4820.47 | kw 3
2789528 | 01 | 0.04572 | 108 | 4820.47 | kw 3
2789538 | 01 | 0.04572 | 202 | 4820.47 | kw 3
2789546 | 01 | 0.04572 | 108 | 4820.47 | kw 3
2789733 | 01 | 0.04572 | 357 | 4177 | kw 3
2789818 | 01 | 0.04572 | 464 | 4152 | kw 3
2789826 | 01 | 0.04572 | 256 | 4152 | kw 3
2789834 | 01 | 0.04572 | 87.4227 | 4152 | kw 3
2789844 | 01 | 0.04572 | 155.925 | 4152 | kw 3
2789993 | 01 | 0.04572 | 621.922 | 4176.99 | kw 3
2790087 | 00 | 0.04572 | 43.3289 | 3377.67 | kw 3
2790090 | 00 | 0.04572 | 959.853 | 3352.22 | kw 3
2790544 | 01 | 0.04572 | 571 | 3214.55 | kw 3
2790734 | 01 | 0.04572 | 168 | 4366 | kw 3
2790751 | 01 | 0.04572 | 326 | 4118.58 | kw 3
2790761 | 01 | 0.04572 | 868.584 | 3243 | kw 3
2790772 | 01 | 0.04572 | 537.272 | 3218 | kw 3
2790827 | 01 | 0.04572 | 59.5786 | 3214.55 | kw 3
2790976 | 01 | 0.04572 | 1231 | 3243 | kw 3
2790984 | 01 | 0.04572 | 116 | 3218 | kw 3
2791100 | 00 | 0.04572 | 495.505 | 3218 | kw 3
2791109 | 01 | 0.04572 | 993.13 | 3218 | kw 3
2791160 | 00 | 0.04572 | 1172 | -684 | kw 3
2791184 | F | 0.04572 | 1062.85 | -720.45 | kw 3
2791382 | F | 0.04572 | 1131.98 | -720.45 | kw 3
2791679 | 00 | 0.04572 | 23.5227 | 493 | kw 3
2791697 | 00 | 0.04572 | 2687 | 512 | kw 3
2791843 | 00 | 0.04572 | 239.503 | 493 | kw 3
2793183 | 01 | 0.04572 | 1479.67 | 3432 | kw 3
2793246 | 01 | 0.04572 | 499 | 4412.67 | kw 3
2793753 | 01 | 0.04572 | 164 | 4389.67 | kw 3
2793763 | 01 | 0.04572 | 787.2 | 3418 | kw 3
2793807 | 01 | 0.04572 | 239 | 4209.2 | kw 3
2793814 | 01 | 0.04572 | 21 | 4209.2 | kw 3
2793817 | 01 | 0.04572 | 151.471 | 4227.2 | kw 3
2793949 | 00 | 0.04572 | 616 | 3393 | kw 3
2793955 | 00 | 0.04572 | 585.505 | 3393 | kw 3
2793965 | 00 | 0.04572 | 54.5 | 3393 | kw 3
2794054 | 00 | 0.04572 | 2554.61 | 3389.55 | kw 3
2794060 | 00 | 0.04572 | 1706.5 | 3389.55 | kw 3
2794133 | 00 | 0.04572 | 1275.89 | 3450.5 | kw 3
2794150 | 00 | 0.04572 | 72 | 3393 | kw 3
2794195 | 00 | 0.04572 | 21.5 | 3418 | kw 3
2794466 | 00 | 0.04572 | 35.0812 | 3398.97 | kw 3
2794478 | 00 | 0.04572 | 151.466 | 3427.08 | kw 3
2795768 | 00 | 0.04572 | 2307 | 575 | ww 5
2795776 | 00 | 0.04572 | 1731.5 | 2893 | ww 5
2795786 | 00 | 0.04572 | 1899 | 983 | ww 5
2796029 | 00 | 0.04572 | 449.5 | 958 | ww 5
2796042 | 00 | 0.04572 | 328.5 | 609 | ww 5
2796133 | 00 | 0.04572 | 1271 | -692 | kw 3
2797232 | F | 0.04572 | 9555.36 | -790.25 | kw BSH
2797567 | F | 0.04572 | 72.8858 | -790.25 | kw BSH
2797588 | F | 0.04572 | 106.6 | 83 | kw 3
2797672 | F | 0.04572 | 803 | -720 | kw BSH
2797696 | 00 | 0.04572 | 54.0503 | 273.75 | kw 3
2797748 | F | 0.04572 | 33.4 | 235.6 | kw 3
2800573 | 01 | 0.04572 | 1030.5 | 3443.5 | kw 3
2800581 | 01 | 0.04572 | 15.033 | 3417.68 | kw 3
2800609 | 00 | 0.04572 | 941 | 3389.55 | kw 3

# IfcFlowSegment: Pipe Types:NLRS_50_PI_UN_Staal - draadverbinding lassok_gen_ISR (3)
In: 00
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipes
Classification: 5- (Uniformat); Group: cva 6
Pset_DistributionFlowElementCommon - Reference: NLRS_50_PI_UN_Staal - draadverbinding lassok_gen_ISR; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.046 mm
Pset_FlowSegmentPipeSegment - InvertElevation: 1016.4 mm
Name (Pipe Types:NLRS_50_PI_UN_Staal - draadverbinding lassok_gen_ISR:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm)
1269615 | 180.582
1269645 | 117.508
1269955 | 293.493

# IfcFlowSegment: Pipe Types:NLRS_50_PI_UN_Staal - draadverbinding t-stuk_gen_ISR (6)
In: 00
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipes
Classification: 5- (Uniformat)
Pset_DistributionFlowElementCommon - Reference: NLRS_50_PI_UN_Staal - draadverbinding t-stuk_gen_ISR; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.046 mm
Name (Pipe Types:NLRS_50_PI_UN_Staal - draadverbinding t-stuk_gen_ISR:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1269476 | 95.1267 | 716.4 | cvr 5
1269507 | 117.508 | 716.4 | cvr 5
1269547 | 180.27 | 616.4 | cva 6
1269575 | 117.508 | 616.4 | cva 6
1269861 | 278.493 | 716.4 | cvr 5
1270011 | 287.493 | 618.67 | cva 6

# IfcFlowSegment: Pipe Types:NLRS_50_PI_UN_Staal - lasverbinding Lasleiding_gen_ISR (148)
In: 00
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipes
Classification: 5- (Uniformat)
Pset_DistributionFlowElementCommon - Reference: NLRS_50_PI_UN_Staal - lasverbinding Lasleiding_gen_ISR; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
Pset_ElementShading - Roughness: 0.046 mm
Name (Pipe Types:NLRS_50_PI_UN_Staal - lasverbinding Lasleiding_gen_ISR:...) | Pset_FlowSegmentDuctSegment, Length (mm) = Pset_FlowSegmentPipeSegment, Length (mm) | InvertElevation (mm) | Group
1246632 | 107.55 | 38 | gkwa 2
1254999 | 145.804 | 1440.58 | brr 1
1259675 | 145.804 | 1736.38 | brr 1
1259809 | 36.2403 | 126.076 | brr 1
1259833 | 45.9632 | 749.501 | brr 1
1262165 | 1560.87 | 1335.58 | bra 3
1262541 | 145.804 | 2030.18 | brr 1
1263805 | 748 | 2983.4 | bra 3
1264257 | 56.4 | 937.677 | brr 1
1264867 | 134.145 | 1011.78 | brr 1
1264880 | 362.792 | 1011.78 | brr 1
1264968 | 1321.08 | 3148.47 | brr 1
1265112 | 311.401 | 964.5 | brr 1
1265426 | 181.841 | 808.45 | brr 1; gkwr 4
1265653 | 346.113 | 158.45 | brr 1; gkwr 4
1265664 | 47.1323 | 314.497 | brr 1
1265787 | 712.588 | 1423.9 | brr 1
1265796 | 612.546 | 3148.45 | brr 1
1265967 | 37.7 | 862.577 | brr 1
1268408 | 700.586 | 2209.44 | brr 1
1268473 | 459.805 | 2209.44 | brr 1
1269398 | 93.4389 | 316.4 | cvr 5
1269419 | 147.508 | 316.4 | cvr 5
1270093 | 287.493 | 316.4 | cvr 5
1270830 | 185.525 | 1172.55 | cva 3
1270848 | 14.55 | 1172.55 | cva 5
