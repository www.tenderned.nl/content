Properties of the parts of a building model (IFC2X3), part 10 of 13

# IfcFlowFitting: NLRS_50_PIF_UN_koper soldeerverbinding verloop bi-bu_gen_ISR:std (248)
Name (NLRS_50_PIF_UN_koper soldeerverbinding verloop bi-bu_gen_ISR:std:...) | In | Group
2277508 | 01 | kw 3
2277512 | 01 | kw 3
2277535 | 01 | kw 3
2277539 | 01 | kw 3
2277592 | 01 | kw 3
2277871 | 01 | kw 3
2278571 | 01 | kw 3
2278576 | 01 | kw 3
2278622 | 01 | kw 3
2278640 | 01 | kw 3
2278658 | 01 | kw 3
2278674 | 01 | kw 3
2278793 | 01 | kw 3
2280767 | 00 | kw 3
2281041 | 00 | kw 3
2282612 | 00 | kw 3
2283222 | 00 | kw 3
2283246 | 00 | kw 3
2283291 | 00 | kw 3
2283313 | 00 | kw 3
2283551 | 00 | kw 3
2283656 | 00 | kw 3
2283715 | 00 | kw 3
2283733 | 00 | kw 3
2284355 | 00 | kw 3
2284360 | 00 | kw 3
2284470 | 00 | kw 3
2285907 | 00 | kw 3
2285912 | 00 | kw 3
2286431 | 00 | kw 3
2287279 | 00 | kw 3
2287299 | 00 | kw 3
2287344 | 00 | kw 53
2287374 | 00 | kw 3
2287412 | 00 | kw 55
2288599 | 00 | kw 3
2288798 | 00 | kw 3
2288803 | 00 | kw 3
2288832 | 00 | kw 3
2288837 | 00 | kw 3
2289671 | 00 | kw 3
2289680 | 00 | kw 3
2289891 | 01 | kw 3
2289896 | 01 | kw 3
2289923 | 01 | kw 3
2289928 | 01 | kw 3
2289955 | 01 | kw 3
2289960 | 01 | kw 3
2289985 | 01 | kw 3
2289990 | 01 | kw 3
2291116 | 01 | kw 3
2292564 | 01 | kw 3
2473695 | 00 | kw 3
2474742 | 00 | kw 3
2479048 | 01 | kw 3
2508284 | 00
2508308 | 00 | ww 2
2508336 | 00 | ww 2
2508448 | 00 | ww 2
2510225 | 00 | ww 2
2511659 | 00 | ww 1
2511861 | 00 | ww 1
2515245 | 01 | ww 5
2517302 | 00 | kw 3
2518193 | 00 | kw 3
2518746 | 00 | kw 3
2518980 | 00 | kw 3
2519025 | 00 | kw 3
2523983 | 00 | kw 3
2524426 | 00 | kw 3
2524482 | 00 | kw 3
2524600 | 00 | kw 3
2524718 | 00 | kw 3
2524938 | 00 | kw 3
2524990 | 00 | kw 3
2537143 | 01 | kw BSH
2537546 | 01 | kw BSH
2538549 | 00 | kw BSH
2538612 | 00 | kw BSH
2538672 | 00 | kw BSH
2573923 | 01 | ww 12
2573986 | 01 | ww 12
2726529 | 00 | cvr 4
2728024 | 00 | gkwa 3
2728071 | 00 | gkwr 2
2728088 | 00 | gkwr 2
2742517 | F | kw 3
2742519 | F | kw 3
2742521 | F | kw 3
2742525 | F | kw 3
2778291 | 01 | kw 3
2778910 | 01 | kw 3
2779434 | 01 | kw 3
2779928 | 01 | ww 10
2779932 | 01 | ww 10
2782840 | 01 | ww 13
2782842 | 01 | ww 17
2782844 | 01 | ww 14
2782846 | 01 | ww 15
2782848 | 01 | ww 16
2782850 | 01 | ww 18
2782852 | 01 | ww 26
2782854 | 01 | ww 30
2782856 | 01 | ww 27
2782858 | 01 | ww 28
2782860 | 01 | ww 29
2782862 | 01 | ww 31
2782892 | 01 | ww 10
2782902 | 01 | ww 10
2784618 | 01 | ww 10
2785206 | 01 | ww 10
2785614 | 01 | kw 3
2785675 | 01 | kw 3
2785868 | 01 | ww 4
2785874 | 01 | kw 3
2786168 | 01 | ww 4
2786226 | 01 | kw 3
2787251 | 01 | kw 3
2787253 | 01 | kw 3
2787267 | 00 | kw 3
2787330 | 00 | kw 3
2787332 | 00 | kw 3
2787447 | 01 | kw 3
2787449 | 01 | kw 3
2788004 | 01 | kw 3
2788280 | 01 | kw 3
2788863 | 01 | kw 3
2789761 | 01 | kw 3
2790033 | 01 | kw 3
2790035 | 01 | kw 3
2790039 | 01 | kw 3
2790049 | 01 | kw 3
2790051 | 01 | kw 3
2790055 | 01 | kw 3
2790057 | 01 | kw 3
2790059 | 01 | kw 3
2790061 | 01 | kw 3
2790063 | 01 | kw 3
2790065 | 01 | kw 3
2790069 | 01 | kw 3
2790071 | 01 | kw 3
2790077 | 00 | kw 3
2790095 | 00 | kw 3
2790158 | 00 | kw 3
2790165 | 00 | kw 3
2790169 | 00 | kw 3
2790806 | 01 | kw 3
2791027 | 01 | kw 3
2791357 | 01 | kw 3
2791359 | 00 | kw 3
2791361 | 00 | kw 3
2791809 | 00 | kw 3
2792063 | 01 | kw 3
2792065 | 01 | kw 3
2792129 | F | kw 3
2792451 | F | kw 3
2792600 | F | kw 3
2792642 | 00 | kw 3
2792644 | 00 | kw 3
2792702 | F | kw 3
2793064 | 00 | kw 3
2793830 | 01 | kw 3
2793832 | 01 | kw 3
2793983 | 01 | kw 3
2794035 | 01 | kw 3
2794037 | 01 | kw 3
2794176 | 00 | kw 3
2794458 | 00 | kw 3
2794595 | F | kw 3
2794668 | F | kw 3
2794721 | 00 | kw 3
2794723 | 00 | kw 3
2794725 | 00 | kw 3
2794851 | F | kw 3
2794853 | F | kw 3
2794871 | F | kw 3
2794894 | 00 | ww 3
2794896 | 00 | ww 3
2794898 | 00 | ww 3
2794900 | 00 | ww 3
2794902 | 00 | ww 3
2794957 | F | kw 3
2794964 | F | kw 3
2795010 | 00 | kw 3
2795048 | F | kw 3
2795073 | 00 | kw 3
2795103 | F | kw 3
2795137 | F | kw 3
2795152 | F | kw 3
2795215 | F | kw 3
2795217 | F | kw 3
2795219 | F | kw 3
2796049 | 00 | ww 5
2796060 | 00 | ww 5
2796078 | 00 | ww 5
2796080 | 00 | ww 5
2796142 | F | kw 3
2796148 | 00 | kw 3
2796219 | 00 | kw 3
2796229 | F | kw 3
2796231 | F | kw 3
2796253 | F | kw 3
2796297 | F | kw 3
2796579 | 00 | kw 3
2796581 | 00 | kw 3
2796676 | 00 | kw 3
2796702 | 00 | kw 3
2796704 | 00 | kw 3
2796711 | 00 | kw 3
2796713 | 00 | kw 3
2796780 | F | kw 3
2796811 | F | kw 3
2796815 | F | kw 3
2796819 | F | kw 3
2796823 | F | kw 3
2796825 | F | kw 3
2796831 | F | kw 3
2796837 | F | kw 3
2796874 | F | kw 3
2796876 | F | kw 3
2796878 | F | kw 3
2796897 | F | kw 3
2796899 | F | kw 3
2796901 | F | kw 3
2796914 | F | kw 3
2796918 | F | kw 3
2796920 | F | kw 3
2796922 | F | kw 3
2796931 | F | kw 3
2796933 | F | kw 3
2797029 | F | kw BSH
2797031 | F | kw BSH
2797043 | F | kw BSH
2797045 | F | kw BSH
2797091 | F | kw BSH
2797093 | F | kw BSH
2797095 | F | kw BSH
2797097 | F | kw BSH
2797128 | 00 | kw 3
2797130 | 00 | kw 3
2797750 | F | kw 3
2799001 | 00 | kw 3
2800066 | F | kw 3
2800616 | 01 | kw 3
2804269 | 00 | gkwa 3
2804271 | 00 | gkwa 3
2885065 | 00 | kw 3
2885067 | F | kw 3

# IfcFlowFitting: NLRS_50_PIF_UN_lasverbinding bocht_gen_ISR:std (72)
In: 00
Type - Classification: 5- (Uniformat); Material: ISR_staal
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIF_UN_lasverbinding bocht_gen_ISR:std:...) | Group
1263556 | bra 3
1264884 | brr 1
1264886 | brr 1
1264994 | brr 1
1264998 | brr 1
1265002 | brr 1
1265474 | brr 1
1265676 | brr 1
1268416 | brr 1
1268486 | brr 1
1268581 | brr 1
1269137 | cvr 5
1269268 | cva 6
1269421 | cvr 5
1269577 | cva 6
1271416 | cvr 3
1274368 | gkwr 1
1274381 | cvr 7 (1)
1275902 | gkwa 2
1275910 | cva 5
1278562 | cva 5
1278608 | cvr 7 (1)
1279611 | cva 5
1279665 | cvr 7 (1)
1280097 | cva 5
1280552 | gkwa 2
1280656 | gkwr 1
1281843 | gkwr 1
1281868 | gkwr 1
1282724 | gkwa 2
1282726 | gkwa 2
1283509 | cvr 7 (1)
1286392 | cva 5
2738983 | cva 3
2739777 | cvr 5
2741032 | cvr 3
2741036 | cvr 3
2741360 | cva 5
2741372 | cva 5
2741393 | cvr 7 (1)
2741408 | cvr 7 (1)
2742834 | gkwr 1
2742836 | gkwr 1
2742840 | gkwa 2
2742842 | gkwa 2
2743242 | brr 1
2743729 | cva 2
2743766 | cva 9
2743805 | cva 11
2743924 | gkwr 1
2743937 | gkwr 1
2743950 | gkwr 1
2743963 | gkwr 1
2911552 | cva 6
2911568 | cvr 5
2911644 | cva 6
2911649 | cva 6
2911657 | cvr 5
2911661 | cvr 5
2911824 | cva 6
2911838 | cvr 5
2911852 | cva 6
2911866 | cvr 5
2912181 | bra 3
2912187 | brr 1
2912553 | cva 3
2912557 | cva 3
2912772 | cva 3
2912776 | cva 3
2912916 | cva 3
2912930 | cva 3
2912979 | cvr 3

# IfcFlowFitting: NLRS_50_PIF_UN_lasverbinding lasbodem_gen_ISR:std (4)
In: 00
Type - Classification: 5- (Uniformat); Material: <Unnamed>, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIF_UN_lasverbinding lasbodem_gen_ISR:std:...) | Group
1274077 | cvr 7 (1)
1274085 | gkwr 1
1275880 | cva 5
1275886 | gkwa 2

# IfcFlowFitting: NLRS_50_PIF_UN_lasverbinding lasleiding_gen_ISR:Hoofdleiding DN100, NLRS_50_PIF_UN_lasverbinding lasleiding_gen_ISR:Hoofdleiding DN100:2743699
In: 00
Type - Material: <Unnamed>, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: n.t.b.
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs; Group: brr 1
Pset_DistributionFlowElementCommon - Reference: Hoofdleiding DN100; sets with these values: 2

# IfcFlowFitting: NLRS_50_PIF_UN_lasverbinding lasleiding_gen_ISR:Hoofdleiding DN125 (31)
In: 00
Type - Classification: 5- (Uniformat); Material: <Unnamed>, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs
Pset_DistributionFlowElementCommon - Reference: Hoofdleiding DN125; sets with these values: 2
Name (NLRS_50_PIF_UN_lasverbinding lasleiding_gen_ISR:Hoofdleiding DN125:...) | Group
1274358 | gkwr 1
1274364 | gkwr 1
1274383 | cvr 7 (1)
1274426 | cvr 7 (1)
1275291 | gkwr 1
1275366 | cvr 7 (1)
1275383 | gkwr 1
1275416 | cvr 7 (1)
1275892 | gkwa 2
1275898 | gkwa 2
1275912 | cva 5
1275918 | cva 5
1275922 | gkwa 2
1275930 | cva 5
1275934 | gkwa 2
1275942 | cva 5
1277341 | cvr 7 (1)
1277525 | gkwr 1
1285646 | cva 5
1285720 | cva 5
1285727 | cva 5
1286161 | gkwr 1
1286170 | cvr 7 (1)
1286179 | gkwr 1
1286188 | cvr 7 (1)
1286197 | gkwr 1
1286206 | cvr 7 (1)
2743886 | cva 9; gkwa 2
2743895 | cva 2; gkwa 2
2743904 | cva 5
2743913 | cva 5

# IfcFlowFitting: NLRS_50_PIF_UN_lasverbinding lasleiding_gen_ISR:Hoofdleiding DN50 (24)
In: 00
Type - Material: <Unnamed>, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: n.t.b.
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs
Pset_DistributionFlowElementCommon - Reference: Hoofdleiding DN50; sets with these values: 2
Name (NLRS_50_PIF_UN_lasverbinding lasleiding_gen_ISR:Hoofdleiding DN50:...) | Group
1285386 | cvr 7 (1)
1285753 | gkwr 1
1285985 | cvr 7 (1)
1285990 | gkwr 1
1286048 | cvr 7 (1)
1286053 | gkwr 1
1286138 | cvr 7 (1)
1286143 | gkwr 1
1286390 | cva 5
1286397 | cva 5
1286402 | cva 5
2743727 | cva 2
2743734 | cva 2
2743739 | cva 2
2743764 | cva 9
2743771 | cva 9
2743776 | cva 9
2743803 | cva 11
2743810 | cva 11
2743815 | cva 11
2743922 | cvr 7 (1); gkwr 1
2743935 | gkwr 1
2743948 | cvr 7 (1); gkwr 1
2743961 | gkwr 1

# IfcFlowFitting: NLRS_50_PIF_UN_lasverbinding lasleiding_gen_ISR:Hoofdleiding DN80 (5)
In: 00
Type - Material: <Unnamed>, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs
Pset_DistributionFlowElementCommon - Reference: Hoofdleiding DN80; sets with these values: 2
Name (NLRS_50_PIF_UN_lasverbinding lasleiding_gen_ISR:Hoofdleiding DN80:...) | Group
1246634 | gkwa 2
1259838 | brr 1
1265510 | brr 1
1265798 | brr 1
1282378 | gkwa 2

# IfcFlowFitting: NLRS_50_PIF_UN_lasverbinding lassok_gen_ISR:Hoofdleiding DN32, NLRS_50_PIF_UN_lasverbinding lassok_gen_ISR:Hoofdleiding DN32:1269647
In: 00
Type - Material: ISR_staal
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 5- (Uniformat); Group: cva 6
Pset_DistributionFlowElementCommon - Reference: Hoofdleiding DN32; sets with these values: 2

# IfcFlowFitting: NLRS_50_PIF_UN_lasverbinding t-stuk_gen_ISR:std (12)
In: 00
Type - Classification: 5- (Uniformat); Material: ISR_staal
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIF_UN_lasverbinding t-stuk_gen_ISR:std:...) | Group
2911814 | cva 6
2911828 | cvr 5
2911842 | cva 6
2911856 | cvr 5
2912197 | brr 1
2912209 | bra 3
2912221 | bra 3
2912233 | brr 1
2912906 | cva 3
2912920 | cva 3
2912985 | cvr 3
2912997 | cvr 3

# IfcFlowFitting: NLRS_50_PIF_UN_lasverbinding verloop_gen_ISR:std (47)
In: 00
Type - Material: <Unnamed>, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Pipe Fittings
Classification: 5- (Uniformat); Material: PVC grijs
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIF_UN_lasverbinding verloop_gen_ISR:std:...) | Group
1269423 | cvr 5
1269579 | cva 6
1280101 | cva 5
1280522 | gkwa 2
1280619 | gkwr 1
1282728 | gkwa 2
1282831 | gkwr 1
1283511 | cvr 7 (1)
2555626 | kw 3
2555632 | kw 3
2739666 | cvr 5
2911533 | cvr 5
2911535 | cva 6
2911647 | cva 6
2911659 | cvr 5
2911715 | cvr 5
2911717 | cva 6
2911780 | cvr 5
2911782 | cva 6
2911822 | cva 6
2911836 | cvr 5
2911850 | cva 6
2911864 | cvr 5
2912032 | cva 3
2912185 | bra 3
2912191 | brr 1
2912205 | brr 1
2912207 | brr 1
2912217 | bra 3
2912219 | bra 3
2912229 | bra 3
2912231 | bra 3
2912241 | brr 1
2912243 | brr 1
2912253 | brr 1
2912255 | bra 3
2912774 | cva 3
2912894 | cva 3
2912900 | cva 3
2912914 | cva 3
2912928 | cva 3
2912981 | cvr 3
2912983 | cvr 3
2912993 | cvr 3
2912995 | cvr 3
2913005 | cvr 3
2913007 | cvr 3

# IfcFlowFitting: NLRS_50_PIF_UN_polderexpantie_Dyka:110 (7)
In: F
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: 110; sets with these values: 2
Group: vwa 1
Name (NLRS_50_PIF_UN_polderexpantie_Dyka:110:...)
2882385
2891408
2892922
2892948
2892974
2893000
2904409

# IfcFlowFitting: NLRS_50_PIF_UN_polderexpantie_Dyka:160, NLRS_50_PIF_UN_polderexpantie_Dyka:160:2917758
In: F
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: 160; sets with these values: 2
Group: hwa 2

# IfcFlowFitting: NLRS_50_PIF_UN_t-stuk_Aquatherm:std (67)
Type - Classification: 50.00 (Uniformat); Material: Aquatherm green
Type - Pset_ManufacturerTypeInformation - Manufacturer: Aquatherm
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIF_UN_t-stuk_Aquatherm:std:...) | In | Group
2260442 | 00 | cva 20
2260493 | 00 | cvr 11
2261383 | 00 | cva 20
2261431 | 00 | cvr 11
2263018 | 00 | cva 20
2263038 | 00 | cvr 11
2263512 | 00 | cva 20
2263532 | 00 | cvr 11
2263975 | 00 | cva 20
2264459 | 00 | cvr 11
2521094 | 00 | cvr 1
2521114 | 00 | cva 1
2521388 | 00 | cva 1
2521408 | 00 | cvr 1
2550511 | 00 | cvr 1
2550531 | 00 | cva 1
2596167 | 00 | cvr 16; cva 20
2596311 | 00 | cvr 11
2717435 | 00 | gkwa 3
2717458 | 00 | gkwa 3
2728284 | 00 | gkwr 2
2728557 | 00 | gkwa 3
2728833 | 00 | gkwr 2
2728981 | 00 | gkwr 2
2780370 | 00 | cvr 1
2780444 | 00 | cva 1
2802682 | 01 | cva 8
2830815 | 00 | cva 1
2830849 | 00 | cvr 1
2831013 | 00 | cva 1
2831050 | 00 | cvr 1
2831083 | 00 | cva 1
2831123 | 00 | cvr 1
2831163 | 00 | cva 1
2831197 | 00 | cvr 1
2831237 | 00 | cvr 1
2831419 | 00 | cvr 1
2831456 | 00 | cva 1
2831495 | 00 | cvr 1
2831530 | 00 | cva 1
2831621 | 00 | cvr 1
2831656 | 00 | cva 1
2831695 | 00 | cvr 1
2831730 | 00 | cva 1
2832145 | 00 | cva 1
2832165 | 00 | cvr 1
2832214 | 00 | cva 1
2832658 | 00 | cva 20
2832742 | 00 | cvr 11
2832842 | 01 | cva 20
2833020 | 00 | cva 20
2833058 | 00 | cvr 11
2833098 | 00 | cva 20
2833130 | 00 | cvr 11
2833178 | 00 | cva 20
2833213 | 00 | cvr 11
2833262 | 00 | cva 20
2833299 | 00 | cvr 11
2833334 | 00 | cvr 11
2833369 | 00 | cva 20
2833406 | 00 | cvr 11
2833495 | 00 | cvr 11
2833680 | 00 | cva 20
2833700 | 00 | cva 20
2833929 | 00 | cvr 11
2834183 | 00 | cva 20
2834191 | 00 | cvr 11

# IfcFlowFitting: NLRS_50_PIF_UN_verloop MS_Aquatherm:std (82)
Type - Material: Aquatherm green
Type - Pset_ManufacturerTypeInformation - Manufacturer: Eriks
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: std; sets with these values: 2
Name (NLRS_50_PIF_UN_verloop MS_Aquatherm:std:...) | In | Group
2729214 | 00 | gkwa 3
2729254 | 00 | gkwr 2
2743490 | 00 | bra 3
2743690 | 00 | brr 1
2832046 | 01 | cvr 1
2832048 | 01 | cva 1
2832057 | 00 | cvr 1
2832059 | 00 | cva 1
2832063 | 00 | cvr 1
2832067 | 00 | cva 1
2832081 | 00 | cvr 1
2832083 | 00 | cva 1
2832089 | 00 | cvr 1
2832091 | 00 | cva 1
2832101 | 01 | cvr 1
2832103 | 01 | cva 1
2832106 | 00 | cvr 1
2832108 | 00 | cva 1
2832123 | 00 | cvr 1
2832125 | 00 | cva 1
2832128 | 01 | cvr 1
2832130 | 01 | cva 1
2832175 | 01 | cvr 1
2832179 | 01 | cva 1
2832235 | 00 | cvr 1
2832237 | 00 | cva 1
2832244 | 00 | cvr 1
2832246 | 00 | cva 1
2832269 | 01 | cvr 1
2832271 | 01 | cva 1
2832273 | 01 | cvr 1
2832275 | 01 | cva 1
2832284 | 00 | cvr 1
2832286 | 00 | cva 1
2832293 | 00 | cva 1
2832295 | 00 | cvr 1
2832299 | 01 | cvr 1
2832301 | 01 | cva 1
2832308 | 00 | cvr 1
2832310 | 00 | cva 1
2832336 | 01 | cvr 1
2832338 | 01 | cva 1
2832340 | 00 | cvr 1
2832342 | 00 | cva 1
2833715 | 00 | cvr 11
2833717 | 00 | cva 20
2833720 | 01 | cvr 11
2833722 | 01 | cva 20
2833735 | 00 | cvr 11
2833737 | 00 | cva 20
2833740 | 00 | cvr 11
2833742 | 00 | cva 20
2833757 | 00 | cvr 11
2833759 | 00 | cva 20
2833792 | 00 | cvr 11
2833794 | 00 | cva 20
2833798 | 01 | cvr 11
2833800 | 01 | cva 20
2833814 | 00 | cva 20
2833818 | 00 | cvr 11
2833826 | 00 | cva 25
2833828 | 00 | cvr 11
2833830 | 00 | cva 20
2833832 | 00 | cvr 16
2833834 | 00 | cva 20
2833836 | 00 | cvr 11
2834080 | 01 | cvr 11
2834082 | 01 | cva 20
2834084 | 01 | cvr 11
2834086 | 01 | cva 20
2834092 | 00 | cvr 11
2834094 | 00 | cva 20
2834097 | 01 | cvr 11
2834099 | 01 | cva 20
2834265 | 00 | cva 20
2834267 | 00 | cvr 11
2834269 | 00 | cvr 11
2834271 | 00 | cva 20
2834277 | 01 | cvr 11
2834279 | 01 | cva 20
2834281 | 00 | cva 20
2834283 | 00 | cvr 11

# IfcFlowFitting: NLRS_52_PIF_UN_DS T-stuk 3FM_SH_Dyka:var. DN/OD (nested) (3)
In: 01
Type - Description: DykaSono Branch; PredefinedType: JUNCTION; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_blauw_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: var. DN/OD (nested); sets with these values: 2
Name (NLRS_52_PIF_UN_DS T-stuk 3FM_SH_Dyka:var. DN/OD (nested):...)
1409153
1546251
1546412

# IfcFlowFitting: NLRS_52_PIF_UN_DS bocht 1FM_SH_Dyka:var. DN/OD (nested) (6)
Type - Description: Dyka Bend; PredefinedType: BEND; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_blauw_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: var. DN/OD (nested); sets with these values: 2
Name (NLRS_52_PIF_UN_DS bocht 1FM_SH_Dyka:var. DN/OD (nested):...) | In
1618631 | 00
1902350 | 00
1942165 | 00
1981846 | 00
1982037 | 00
2476518 | 01

# IfcFlowFitting: NLRS_52_PIF_UN_DS bocht 2FM_SH_Dyka:var. DN/OD (nested) (8)
Type - Description: Dyka Bend; PredefinedType: BEND; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_blauw_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: var. DN/OD (nested); sets with these values: 2
Name (NLRS_52_PIF_UN_DS bocht 2FM_SH_Dyka:var. DN/OD (nested):...) | In
1618633 | 00
1902352 | 00
1942167 | 00
1981848 | 00
1982039 | 00
2048743 | 00
2048745 | 00
2476520 | 01

# IfcFlowFitting: NLRS_52_PIF_UN_DS multi T-stuk 3FM_Dyka:Vert. buis + Hor. T-stuk (standleiding) (3)
In: 01
Type - Description: Dyka Assembly; PredefinedType: JUNCTION; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_blauw_Dyka, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs
Pset_DistributionFlowElementCommon - Reference: Vert. buis + Hor. T-stuk (standleiding); sets with these values: 2
Name (NLRS_52_PIF_UN_DS multi T-stuk 3FM_Dyka:Vert. buis + Hor. T-stuk (standleiding):...) | Group
1409151 | o 4; vwa 1
1546249 | o 9; vwa 1
1546410 | vwa 1

# IfcFlowFitting: NLRS_52_PIF_UN_DS multi bocht_Dyka:var. DN/OD (7)
Type - Description: Dyka Assembly; PredefinedType: BEND; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_blauw_Dyka, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs; Group: vwa 1
Pset_DistributionFlowElementCommon - Reference: var. DN/OD; sets with these values: 2
Name (NLRS_52_PIF_UN_DS multi bocht_Dyka:var. DN/OD:...) | In
1618629 | 00
1902348 | 00
1942163 | 00
1981844 | 00
1982035 | 00
2048710 | 00
2476516 | 01

# IfcFlowFitting: NLRS_52_PIF_UN_HWA PVC bocht 1LV VS_SH_Dyka:Grijs, var. DN/OD (nested) (43)
Type - Description: Dyka Bend; PredefinedType: BEND; Classification: 52.10 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Grijs, var. DN/OD (nested); sets with these values: 2
Name (NLRS_52_PIF_UN_HWA PVC bocht 1LV VS_SH_Dyka:Grijs, var. DN/OD (nested):...) | In
2499197 | 01
2499205 | 01
2499305 | 01
2499313 | 01
2499349 | 01
2499357 | 01
2499393 | 01
2499401 | 01
2499437 | 01
2499445 | 01
2501065 | 01
2523544 | 02
2523556 | 02
2523620 | 02
2523626 | 02
2821193 | 01
2821227 | 01
2821263 | 01
2821299 | 01
2821335 | 01
2825784 | 01
2825859 | 01
2825867 | 01
2826411 | 01
2826417 | 01
2826433 | 01
2826439 | 01
2826445 | 01
2826451 | 01
2885289 | 01
2885295 | 01
2886286 | 01
2886292 | 01
2886315 | 01
2886321 | 01
2886342 | 01
2886348 | 01
2886421 | 01
2886439 | 01
2886453 | 01
2886662 | 01
2886668 | 01
2889366 | 01

# IfcFlowFitting: NLRS_52_PIF_UN_HWA PVC multi bocht assembly_Dyka:Grijs, Var. DN/OD (43)
Type - Description: Dyka Assembly; PredefinedType: BEND; Classification: 52 (Uniformat); Material: PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Grijs, Var. DN/OD; sets with these values: 2
Name (NLRS_52_PIF_UN_HWA PVC multi bocht assembly_Dyka:Grijs, Var. DN/OD:...) | In | Group
2499195 | 01 | hwa 2
2499203 | 01 | hwa 2
2499303 | 01 | hwa 2
2499311 | 01 | hwa 2
2499347 | 01 | hwa 2
2499355 | 01 | hwa 2
2499391 | 01 | hwa 2
2499399 | 01 | hwa 2
2499435 | 01 | hwa 2
2499443 | 01 | hwa 2
2501063 | 01 | hwa 2
2523542 | 02 | hwa 1
2523554 | 02 | hwa 1
2523618 | 02 | hwa 3
2523624 | 02 | hwa 3
2821191 | 01 | hwa 2
2821225 | 01 | hwa 2
2821261 | 01 | hwa 2
2821297 | 01 | hwa 2
2821333 | 01 | hwa 2
2825782 | 01 | hwa 2
2825857 | 01 | hwa 2
2825865 | 01 | hwa 2
2826409 | 01 | hwa 2
2826415 | 01 | hwa 2
2826431 | 01 | hwa 2
2826437 | 01 | hwa 2
2826443 | 01 | hwa 2
2826449 | 01 | hwa 2
2885287 | 01 | hwa 2
2885293 | 01 | hwa 2
2886284 | 01 | hwa 2
2886290 | 01 | hwa 2
2886313 | 01 | hwa 2
2886319 | 01 | hwa 2
2886340 | 01 | hwa 2
2886346 | 01 | hwa 2
2886419 | 01 | hwa 2
2886437 | 01 | hwa 2
2886451 | 01 | hwa 2
2886660 | 01 | hwa 2
2886666 | 01 | hwa 2
2889364 | 01 | hwa 2

# IfcFlowFitting: NLRS_52_PIF_UN_HWA PVC verloopstuk VK rond 1LV VS_Dyka:Grijs, var. DN/OD (11)
In: 01
Type - Description: Dyka Transition square - round; PredefinedType: CONNECTOR; Classification: 52.10 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Grijs, var. DN/OD; sets with these values: 2
Group: hwa 2
Name (NLRS_52_PIF_UN_HWA PVC verloopstuk VK rond 1LV VS_Dyka:Grijs, var. DN/OD:...)
2499178
2499286
2499330
2499374
2499418
2501049
2501092
2501137
2501182
2503245
2825849

# IfcFlowFitting: NLRS_52_PIF_UN_PVC T-stuk 3LV_SH_Dyka:Grijs, var. DN/OD (nested) (126)
Type - Description: Dyka Branch; PredefinedType: JUNCTION; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Grijs, var. DN/OD (nested); sets with these values: 2
Name (NLRS_52_PIF_UN_PVC T-stuk 3LV_SH_Dyka:Grijs, var. DN/OD (nested):...) | In
1411103 | 00
1411210 | 00
1411244 | 00
1411287 | 00
1411487 | 00
1411505 | 00
1411523 | 00
1411543 | 00
1413518 | 00
1413563 | 00
1414155 | 00
1414159 | 00
1552025 | 00
1572717 | 01
1572798 | 01
1573081 | 01
1694158 | 00
1941905 | 00
1942210 | 00
1969560 | 00
1969826 | 00
1970151 | F
1971485 | F
1971926 | F
1971973 | F
1972583 | F
1973271 | F
1973316 | F
1973337 | F
1973473 | F
1973604 | F
1973659 | F
1974060 | 00
1975243 | F
1975293 | F
1975357 | F
1975662 | F
1976842 | F
1976876 | F
1979609 | F
1979976 | F
1980280 | F
1981615 | F
1982031 | F
1982143 | F
1982442 | F
1982583 | F
1984917 | 00
1986059 | F
1986244 | F
1986329 | F
2042821 | F
2047047 | F
2047088 | F
2047652 | F
2047827 | F
2048189 | F
2120781 | F
2122200 | F
2122380 | F
2122415 | F
2128454 | F
2128516 | F
2128732 | F
2293620 | F
2294051 | F
2294204 | F
2295866 | 00
2295926 | 00
2296538 | 00
2297590 | F
2298036 | F
2298486 | F
2298617 | F
2298650 | F
2298879 | F
2300165 | 00
2300342 | 00
2424409 | F
2473326 | 00
2473551 | 00
2473907 | F
2475191 | F
2475463 | F
2476233 | 00
2476538 | 00
2476687 | 00
2479694 | 00
2481057 | 01
2524034 | F
2572640 | 01
2821156 | 01
2821201 | 01
2821235 | 01
2821271 | 01
2821307 | 01
2825802 | 01
2825871 | 01
2825994 | 01
2826033 | 01
2826076 | 01
2853652 | 00
2854385 | 00
2855347 | 00
2884540 | F
2885153 | 01
2885862 | 01
2885890 | 01
2885916 | 01
2886413 | 01
2886445 | 01
2892801 | F
2892934 | F
2892960 | F
2892986 | F
2893012 | F
2904268 | F
2905020 | F
2908284 | 02
2909061 | 02
2913829 | 00
2913917 | 00
2914013 | 00
2916832 | 01
2916840 | 01
2917529 | 02

# IfcFlowFitting: NLRS_52_PIF_UN_PVC afsluitkap 1LV_Dyka:Grijs, var. DN/OD, NLRS_52_PIF_UN_PVC afsluitkap 1LV_Dyka:Grijs, var. DN/OD:2455493
In: F
Type - Description: Dyka Endcap; PredefinedType: USERDEFINED; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Grijs, var. DN/OD; sets with these values: 2
Group: vwa 7

# IfcFlowFitting: NLRS_52_PIF_UN_PVC bocht 1LV_SH_Dyka:Grijs, var. DN/OD (nested) (209)
Type - Description: Dyka Bend; PredefinedType: BEND; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Grijs, var. DN/OD (nested); sets with these values: 2
Name (NLRS_52_PIF_UN_PVC bocht 1LV_SH_Dyka:Grijs, var. DN/OD (nested):...) | In
1411089 | 01
1411105 | 00
1411202 | 01
1411212 | 00
1411236 | 01
1411246 | 00
1411279 | 01
1411289 | 00
1411483 | 01
1411489 | 00
1411501 | 01
1411507 | 00
1411519 | 01
1411525 | 00
1411537 | 01
1411545 | 00
1413510 | 01
1413555 | 01
1414198 | 00
1414221 | 00
1414296 | 00
1488909 | 00
1488941 | 00
1551861 | 00
1552027 | 00
1572465 | 01
1572525 | 01
1572711 | 01
1572719 | 01
1572729 | 01
1572779 | 01
1573294 | 01
1694150 | 01
1694160 | 00
1695125 | 00
1695499 | 01
1902403 | 01
1941765 | 00
1942202 | 00
1969394 | 01
1969818 | 00
1969828 | 00
1970127 | 00
1970418 | 00
1971477 | 00
1971487 | F
1971495 | 00
1971965 | 00
1971975 | F
1973193 | 00
1973308 | 00
1973318 | F
1973339 | F
1973540 | F
1973651 | 00
1973661 | F
1974062 | 00
1974523 | 00
1974782 | F
1975235 | 00
1975301 | 00
1975365 | 00
1976184 | 00
1976458 | 00
1976510 | 00
1976630 | 00
1976834 | 00
1977003 | F
1977013 | 00
1979846 | 00
1981198 | 00
1981231 | 00
1981247 | 00
1981392 | 00
1981524 | F
1982033 | F
1982057 | 00
1982424 | 00
1982444 | F
1982575 | 00
1986061 | F
1986246 | F
1986262 | 00
1986331 | F
1986339 | 00
2043761 | 00
2047039 | 00
2047591 | 00
2047829 | F
2047955 | F
2048205 | 00
2048694 | 00
2120278 | 00
2120861 | 00
2120957 | 00
2122311 | 00
2122463 | 00
2122501 | F
2128437 | 00
2128456 | F
2128518 | F
2128726 | F
2128734 | F
2227346 | 00
2227380 | 00
2288445 | F
2293116 | 00
2293930 | 00
2294254 | 00
2295928 | 00
2295936 | 00
2296123 | 00
2296528 | 00
2296611 | 00
2296866 | 00
2297553 | 00
2297851 | 00
2298121 | F
2298390 | 00
2298488 | F
2298619 | F
2298652 | F
2298709 | F
2298726 | F
2298903 | F
2300167 | 00
2300299 | 00
2300344 | 00
2300360 | 01
2424359 | 00
2428827 | 00
2455989 | F
2470686 | 00
2472753 | 00
2472814 | 00
2473328 | 00
2473403 | 00
2473553 | 00
2474056 | F
2475135 | 00
2475448 | 00
2475960 | 01
2476003 | 01
2476634 | 01
2476689 | 00
2479714 | 00
2480617 | 01
2502222 | 00
2524036 | F
2524091 | F
2524128 | F
2568399 | 01
2570184 | 01
2572469 | 01
2572550 | 01
2572642 | 01
2610794 | 01
2818367 | 00
2825804 | 01
2825873 | 01
2825996 | 01
2826035 | 01
2826078 | 01
2853654 | 00
2853786 | F
2853847 | 00
2854135 | 00
2854387 | 00
2854395 | 00
2855349 | 00
2884542 | F
2885155 | 01
2885829 | F
2885837 | 01
2885864 | 01
2885892 | 01
2885918 | 01
2886763 | F
2886808 | F
2892803 | F
2892936 | F
2892962 | F
2892988 | F
2893014 | F
2904049 | 01
2904270 | F
2904675 | F
2905022 | F
2908286 | 02
2909063 | 02
2909131 | 02
2913831 | 00
2913839 | 01
2913907 | 00
2913919 | 00
2913929 | 01
2914038 | 00
2914112 | 00
2914699 | 00
2916691 | 01
2916834 | 01
2916842 | 01
2917531 | 02
2917549 | 02
2917557 | 02
2917624 | 01
2917636 | 01
2919100 | F
2919110 | 00

# IfcFlowFitting: NLRS_52_PIF_UN_PVC bocht 2LV_SH_Dyka:Grijs, var. DN/OD (nested) (226)
Type - Description: Dyka Bend; PredefinedType: BEND; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Grijs, var. DN/OD (nested); sets with these values: 2
Name (NLRS_52_PIF_UN_PVC bocht 2LV_SH_Dyka:Grijs, var. DN/OD (nested):...) | In
1409147 | 01
1411087 | 01
1411200 | 01
1411234 | 01
1411277 | 01
1411481 | 01
1411499 | 01
1411517 | 01
1411535 | 01
1413508 | 01
1413553 | 01
1414196 | 00
1414219 | 00
1414294 | 00
1488907 | 00
1488939 | 00
1546245 | 01
1546406 | 01
1547015 | 00
1551814 | 00
1551859 | 00
1552013 | 01
1572463 | 01
1572523 | 01
1572709 | 01
1572727 | 01
1572777 | 01
1573292 | 01
1573300 | 01
1692223 | 00
1692588 | 00
1694148 | 01
1694250 | 00
1695123 | 00
1695497 | 01
1902401 | 01
1941763 | 00
1941917 | 00
1942200 | 00
1969392 | 01
1969816 | 00
1970125 | 00
1970163 | F
1970416 | 00
1971475 | 00
1971493 | 00
1971932 | F
1971963 | 00
1972587 | F
1973191 | 00
1973275 | F
1973306 | 00
1973477 | F
1973538 | F
1973616 | F
1973649 | 00
1974521 | 00
1974780 | F
1974788 | 00
1974790 | 00
1975233 | 00
1975299 | 00
1975363 | 00
1975674 | F
1976182 | 00
1976456 | 00
1976508 | 00
1976628 | 00
1976832 | 00
1976854 | F
1977001 | F
1977011 | 00
1979844 | 00
1979980 | F
1980284 | F
1981196 | 00
1981229 | 00
1981245 | 00
1981390 | 00
1981522 | F
1981554 | F
1982055 | 00
1982147 | F
1982422 | 00
1982573 | 00
1984943 | 00
1986136 | 00
1986260 | 00
1986337 | 00
2043759 | 00
2047037 | 00
2047558 | F
2047589 | 00
2047664 | F
2047919 | F
2047953 | F
2048203 | 00
2048692 | 00
2120276 | 00
2120304 | F
2120859 | 00
2120955 | 00
2120963 | F
2122309 | 00
2122328 | F
2122391 | F
2122461 | 00
2122480 | F
2122499 | F
2127828 | F
2128435 | 00
2128724 | F
2227344 | 00
2227372 | 00
2227378 | 00
2288443 | F
2293114 | 00
2293632 | F
2293928 | 00
2294063 | F
2294252 | 00
2295934 | 00
2296121 | 00
2296526 | 00
2296609 | 00
2296645 | 00
2296864 | 00
2296885 | 00
2297551 | 00
2297602 | F
2297849 | 00
2297869 | F
2297891 | F
2298048 | F
2298119 | F
2298388 | 00
2298500 | 00
2298707 | F
2298724 | F
2298901 | F
2300264 | 00
2300297 | 00
2300358 | 01
2424357 | 00
2424434 | F
2428762 | 01
2428825 | 00
2455456 | F
2455477 | F
2455987 | F
2470684 | 00
2472751 | 00
2472812 | 00
2473383 | 00
2473401 | 00
2473588 | 00
2474054 | F
2475133 | 00
2475203 | F
2475446 | 00
2475958 | 01
2476001 | 01
2476020 | 01
2476239 | 00
2476632 | 01
2476701 | 01
2479712 | 00
2480609 | 00
2480615 | 01
2481049 | 01
2502220 | 00
2502261 | F
2524089 | F
2524126 | F
2568397 | 01
2570182 | 01
2572158 | 01
2572467 | 01
2572528 | 01
2572548 | 01
2572652 | 01
2610786 | 00
2610792 | 01
2818365 | 00
2853666 | 00
2853784 | F
2853845 | 00
2854105 | 00
2854133 | 00
2854393 | 00
2855038 | 00
2855353 | 00
2855382 | 00
2855407 | 00
2855411 | 00
2858851 | 00
2885827 | F
2885835 | 01
2886761 | F
2886806 | F
2904047 | 01
2904278 | F
2904299 | F
2904673 | F
2908834 | 02
2909045 | 02
2909069 | 02
2909129 | 02
2913837 | 01
2913905 | 00
2913911 | 00
2913927 | 01
2913988 | 00
2914036 | 00
2914102 | F
2914110 | 00
2914697 | 00
2914705 | 00
2916689 | 01
2917547 | 02
2917555 | 02
2917622 | 01
2917634 | 01
2919037 | 00
2919098 | F
2919108 | 00

# IfcFlowFitting: NLRS_52_PIF_UN_PVC multi T-stuk Grijs_Dyka:Hor. buis + Hor. T-stuk (liggend) (125)
Type - Description: Dyka Assembly; PredefinedType: JUNCTION; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs
Pset_DistributionFlowElementCommon - Reference: Hor. buis + Hor. T-stuk (liggend); sets with these values: 2
Name (NLRS_52_PIF_UN_PVC multi T-stuk Grijs_Dyka:Hor. buis + Hor. T-stuk (liggend):...) | In | Group
1411099 | 00 | vwa 1
1411206 | 00 | vwa 1
1411240 | 00 | vwa 1
1411283 | 00 | vwa 1
1411485 | 00 | vwa 1
1411503 | 00 | vwa 1
1411521 | 00 | vwa 1
1411539 | 00 | vwa 1
1413514 | 00 | vwa 1
1413559 | 00 | vwa 1
1414151 | 00 | vwa 1
1414157 | 00 | vwa 1
1552021 | 00 | o 5; vwa 1
1572713 | 01 | o 1; vwa 1
1572794 | 01 | vwa 1
1573075 | 01 | o 1
1694154 | 00 | o 8; vwa 1
1941892 | 00 | vwa 1
1942206 | 00 | vwa 1
1969556 | 00 | vwa 1
1969822 | 00 | vwa 1
1970147 | F | vwa 1
1971481 | F | vwa 1
1971922 | F | vwa 1
1971969 | F | vwa 1
1972579 | F | vwa 1
1973267 | F | vwa 1
1973312 | F | vwa 1
1973333 | F | vwa 1
1973469 | F | vwa 1
1973590 | F | vwa 1
1973655 | F | vwa 1
1974058 | 00 | vwa 7; o 2
1975239 | F | vwa 1
1975289 | F | vwa 1
1975353 | F | vwa 1
1975658 | F | vwa 1
1976838 | F | vwa 1
1976874 | F | vwa 1
1979605 | F | vwa 1
1979972 | F | vwa 1
1980276 | F | vwa 1
1981613 | F | vwa 1
1982026 | F | vwa 1
1982138 | F | vwa 1
1982438 | F | vwa 1
1982579 | F | vwa 1
1984913 | 00 | vwa 1
1986057 | F | o 11; vwa 1
1986240 | F | vwa 1
1986325 | F | vwa 1
2042817 | F | vwa 1
2047043 | F | vwa 1
2047084 | F | vwa 1
2047648 | F | vwa 1
2047823 | F | vwa 1
2048185 | F | vwa 1
2120779 | F | o 6; vwa 1
2122194 | F | vwa 1
2122374 | F | vwa 1
2122410 | F | vwa 1
2128450 | F | vwa 1
2128512 | F | o 11
2128728 | F | vwa 1
2293616 | F | vwa 1
2294047 | F | vwa 1
2294189 | F | vwa 1
2295862 | 00 | vwa 1
2295922 | 00 | vwa 1
2296534 | 00 | o 13; vwa 1
2297586 | F | vwa 1
2298032 | F | vwa 1
2298482 | F | vwa 1
2298613 | F | vwa 1
2298646 | F | vwa 1
2298875 | F | vwa 1
2300160 | 00 | vwa 1
2300338 | 00 | vwa 1
2424395 | F | vwa 1
2473322 | 00 | vwa 1
2473547 | 00 | vwa 1
2473902 | F | vwa 1
2475187 | F | vwa 1
2475459 | F | vwa 1
2476223 | 00 | vwa 1
2476524 | 00 | vwa 1
2476673 | 00 | vwa 1
2479690 | 00 | vwa 1
2524030 | F | vwa 1
2572636 | 01 | o 10
2821140 | 01 | hwa 2
2821197 | 01 | hwa 2
2821231 | 01 | hwa 2
2821267 | 01 | hwa 2
2821303 | 01 | hwa 2
2825786 | 01 | hwa 2
2825869 | 01 | hwa 2
2825992 | 01 | hwa 2
2826031 | 01 | hwa 2
2826074 | 01 | hwa 2
2853648 | 00 | o 3; vwa 1
2854381 | 00 | vwa 9
2855343 | 00 | vwa 9
2884536 | F | vwa 1
2885151 | 01 | hwa 2
2885860 | 01 | hwa 2
2885888 | 01 | hwa 2
2885914 | 01 | hwa 2
2886411 | 01 | hwa 2
2886443 | 01 | hwa 2
2892797 | F | vwa 1
2892932 | F | vwa 1
2892958 | F | vwa 1
2892984 | F | vwa 1
2893010 | F | vwa 1
2904264 | F | hwa 2
2905016 | F | vwa 1
2908280 | 02 | vwa 1
2909059 | 02 | vwa 1
2913825 | 00 | vwa 1
2913913 | 00 | o 10; vwa 1
2914011 | 00 | vwa 1
2916828 | 01 | vwa 1
2916836 | 01 | vwa 1
2917525 | 02 | vwa 1

# IfcFlowFitting: NLRS_52_PIF_UN_PVC multi T-stuk Grijs_Dyka:Vert. buis + Hor. T-stuk (standleiding), NLRS_52_PIF_UN_PVC multi T-stuk Grijs_Dyka:Vert. buis + Hor. T-stuk (standleiding):2481053
In: 01
Type - Description: Dyka Assembly; PredefinedType: JUNCTION; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka, PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: PVC grijs; Group: o 12; vwa 1
Pset_DistributionFlowElementCommon - Reference: Vert. buis + Hor. T-stuk (standleiding); sets with these values: 2

# IfcFlowFitting: NLRS_52_PIF_UN_PVC multi bocht_Dyka:Grijs, Var. DN/OD (227)
Type - Description: Dyka Assembly; PredefinedType: BEND; Classification: 52 (Uniformat); Material: PVC grijs
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Grijs, Var. DN/OD; sets with these values: 2
Name (NLRS_52_PIF_UN_PVC multi bocht_Dyka:Grijs, Var. DN/OD:...) | In | Group
1406167 | 01 | vwa 3
1409145 | 01 | vwa 1
1411083 | 01 | vwa 1
1411196 | 01 | vwa 1
1411230 | 01 | vwa 1
1411273 | 01 | vwa 1
1411477 | 01 | vwa 1
1411495 | 01 | vwa 1
1411513 | 01 | vwa 1
1411531 | 01 | vwa 1
1413504 | 01 | vwa 1
1413549 | 01 | vwa 1
1414192 | 00 | vwa 1
1414215 | 00 | vwa 1
1414290 | 00 | vwa 1
1488903 | 00 | vwa 1
1488935 | 00 | vwa 1
1546243 | 01 | vwa 1
1546404 | 01 | vwa 1
1547013 | 00 | vwa 1
1551812 | 00 | vwa 1
1551855 | 00 | vwa 1
1552011 | 01 | o 5
1572459 | 01 | vwa 1
1572519 | 01 | vwa 1
1572705 | 01 | vwa 1
1572723 | 01 | o 1
1572773 | 01 | vwa 1
1573288 | 01 | o 1
1573298 | 01 | o 1
1692221 | 00 | vwa 1
1692586 | 00 | o 1
1694144 | 01 | o 8
1694248 | 00 | vwa 1
1695119 | 00 | vwa 1
1695493 | 01 | vwa 1
1902397 | 01 | vwa 1
1941759 | 00 | vwa 1
1941915 | 00 | vwa 1
1942196 | 00 | vwa 1
1969388 | 01 | vwa 1
1969812 | 00 | vwa 1
1970121 | 00 | vwa 1
1970161 | F | vwa 1
1970412 | 00 | vwa 1
1971471 | 00 | vwa 1
1971489 | 00 | vwa 1
1971930 | F | vwa 1
1971959 | 00 | vwa 1
1972585 | F | vwa 1
1973187 | 00 | vwa 1
1973273 | F | vwa 1
1973302 | 00 | vwa 1
1973475 | F | vwa 1
1973534 | F | vwa 1
1973614 | F | vwa 1
1973645 | 00 | vwa 1
1974517 | 00 | vwa 1
1974776 | F | vwa 1
1974784 | 00 | vwa 1
1975229 | 00 | vwa 1
1975295 | 00 | vwa 1
1975359 | 00 | vwa 1
1975672 | F | vwa 1
1976178 | 00 | vwa 1
1976452 | 00 | vwa 1
1976504 | 00 | vwa 1
1976624 | 00 | vwa 1
1976828 | 00 | vwa 1
1976852 | F | vwa 1
1976997 | F | vwa 1
1977007 | 00 | vwa 1
1979840 | 00 | vwa 1
1979978 | F | vwa 1
1980282 | F | vwa 1
1981192 | 00 | o 6
1981225 | 00 | o 6
1981241 | 00 | o 6
1981386 | 00 | o 6
1981518 | F | vwa 1
1981552 | F | vwa 1
1982051 | 00 | vwa 1
1982145 | F | vwa 1
1982418 | 00 | vwa 1
1982569 | 00 | vwa 1
1984941 | 00 | vwa 1
1986134 | 00 | o 11; vwa 1
1986256 | 00 | vwa 1
1986333 | 00 | vwa 1
2043755 | 00 | vwa 1
2047033 | 00 | vwa 1
2047556 | F | vwa 1
2047585 | 00 | vwa 1
2047662 | F | vwa 1
2047917 | F | vwa 1
2047949 | F | vwa 1
2048199 | 00 | vwa 1
2048688 | 00 | vwa 1
2120272 | 00 | vwa 1
2120302 | F | vwa 1
2120855 | 00 | o 6
2120951 | 00 | vwa 1
2120961 | F | vwa 1
2122275 | 00 | vwa 1
2122322 | F | vwa 1
2122389 | F | vwa 1
2122427 | 00 | vwa 1
2122474 | F | vwa 1
2122495 | F | vwa 1
2127826 | F | vwa 1
2128431 | 00 | vwa 1
2128720 | F | o 11
2227340 | 00 | o 2
2227370 | 00 | o 2
2227374 | 00 | o 2
2288439 | F | vwa 1
2293110 | 00 | vwa 1
2293630 | F | vwa 1
2293924 | 00 | vwa 1
2294061 | F | vwa 1
2294215 | 00 | vwa 1
2295930 | 00 | vwa 1
2296117 | 00 | o 13
2296522 | 00 | vwa 1
2296605 | 00 | o 13
2296643 | 00 | vwa 1
2296860 | 00 | vwa 1
2296883 | 00 | vwa 1
2297547 | 00 | vwa 1
2297600 | F | vwa 1
2297845 | 00 | vwa 1
2297867 | F | vwa 1
2297889 | F | vwa 1
2298046 | F | vwa 1
2298090 | F | vwa 1
2298384 | 00 | vwa 1
2298498 | 00 | vwa 1
2298678 | F | vwa 1
2298720 | F | vwa 1
2298897 | F | vwa 1
2300262 | 00 | vwa 1
2300293 | 00 | vwa 1
2300354 | 01 | vwa 1
2424172 | F | vwa 11
2424353 | 00 | vwa 1
2424432 | F | vwa 1
2428760 | 01 | vwa 1
2428821 | 00 | vwa 1
2455454 | F | o 2; vwa 1
2455475 | F | vwa 7
2455983 | F | vwa 1
2470680 | 00 | vwa 1
2472747 | 00 | vwa 1
2472808 | 00 | vwa 1
2473381 | 00 | vwa 1
2473397 | 00 | vwa 1
2473586 | 00 | vwa 1
2474020 | F | vwa 1
2475099 | 00 | vwa 1
2475201 | F | vwa 1
2475412 | 00 | vwa 1
2475954 | 01 | vwa 1
2475997 | 01 | vwa 1
2476018 | 01 | vwa 1
2476237 | 00 | vwa 1
2476628 | 01 | vwa 1
2476699 | 01 | vwa 1
2479708 | 00 | vwa 1
2480607 | 00 | vwa 1
2480611 | 01 | vwa 1
2481047 | 01 | vwa 1
2502216 | 00 | o 11
2502259 | F | o 11
2524085 | F | vwa 1
2524122 | F | vwa 1
2568393 | 01 | o 10
2570178 | 01 | vwa 1
2572156 | 01 | o 10
2572433 | 01 | o 10
2572522 | 01 | o 10
2572544 | 01 | o 10
2572646 | 01 | o 10
2610784 | 00 | o 6
2610788 | 01 | o 6
2818361 | 00 | vwa 1
2853664 | 00 | vwa 1
2853780 | F | vwa 1
2853841 | 00 | o 3
2854103 | 00 | vwa 9
2854129 | 00 | vwa 9
2854389 | 00 | vwa 9
2855036 | 00 | vwa 1
2855351 | 00 | vwa 9
2855380 | 00 | vwa 9
2855405 | 00 | vwa 9
2855409 | 00 | vwa 9
2858849 | 00 | vwa 1
2885823 | F | hwa 2
2885831 | 01 | hwa 2
2886757 | F | hwa 2
2886802 | F | hwa 2
2904043 | 01 | hwa 2
2904272 | F | hwa 2
2904297 | F | hwa 2
2904669 | F | vwa 1
2908832 | 02 | vwa 1
2909043 | 02 | vwa 1
2909067 | 02 | vwa 1
2909125 | 02 | vwa 1
2913833 | 01 | vwa 1
2913901 | 00 | vwa 1
2913909 | 00 | vwa 1
2913923 | 01 | o 10
2913986 | 00 | vwa 1
2914032 | 00 | vwa 1
2914100 | F | vwa 1
2914106 | 00 | vwa 1
2914693 | 00 | vwa 1
2914703 | 00 | vwa 1
2916685 | 01 | vwa 1
2917543 | 02 | vwa 1
2917551 | 02 | vwa 1
2917618 | 01 | vwa 1
2917630 | 01 | vwa 1
2919035 | 00 | vwa 1
2919094 | F | vwa 1
2919104 | 00 | vwa 1

# IfcFlowFitting: NLRS_52_PIF_UN_PVC multi reducer_Dyka:Grijs, var. DN/OD (73)
Type - Description: Dyka Assembly; PredefinedType: BEND; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka, Aluminum, Anodized Red
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Material: Aluminum, Anodized Red, PVC grijs; Group: vwa 1
Pset_DistributionFlowElementCommon - Reference: Grijs, var. DN/OD; sets with these values: 2
Name (NLRS_52_PIF_UN_PVC multi reducer_Dyka:Grijs, var. DN/OD:...) | In
1409139 | 01
1410150 | 01
1410202 | 01
1410220 | 01
1410240 | 01
1410260 | 01
1410296 | 01
1410327 | 01
1411389 | 01
1411397 | 01
1411405 | 01
1411413 | 01
1411421 | 01
1414202 | 01
1414225 | 01
1546237 | 01
1546398 | 01
1551874 | 00
1552050 | 00
1617658 | 00
1618083 | 00
1618175 | 00
1618215 | 00
1618305 | 00
1618313 | 00
1618321 | 00
1618436 | 00
1618465 | 00
1619044 | 00
1694186 | 00
1695668 | 00
1968761 | 00
1970129 | 00
1970327 | 00
1973553 | F
1981528 | 00
2047604 | 00
2047959 | 00
2048229 | 00
2120249 | 00
2120901 | 00
2122102 | 00
2122110 | 00
2122503 | 00
2128473 | 00
2288458 | F
2293947 | 00
2294337 | 00
2296530 | 00
2296894 | 00
2297555 | 00
2297853 | 00
2298175 | F
2298776 | F
2298787 | F
2298916 | F
2479718 | 00
2480866 | 01
2552911 | 00
2567949 | 01
2818380 | 00
2892781 | F
2892928 | F
2892954 | F
2892980 | F
2893006 | F
2905032 | F
2905052 | F
2913841 | 01
2913957 | 00
2914375 | 00
2914658 | 00
2917626 | 01

# IfcFlowFitting: NLRS_52_PIF_UN_PVC multi reducer_SH_Dyka:Grijs, var. DN/OD (nested) (42)
Type - Description: Dyka Assembly; PredefinedType: TRANSITION; Classification: 52 (Uniformat); Material: Aluminum, Anodized Red
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Grijs, var. DN/OD (nested); sets with these values: 2
Name (NLRS_52_PIF_UN_PVC multi reducer_SH_Dyka:Grijs, var. DN/OD (nested):...) | In
1941907 | 00
1942212 | 00
1969562 | 00
1969830 | 00
1970153 | F
1973384 | F
1973606 | F
1975664 | F
1976844 | F
1982479 | F
1982585 | F
1986063 | F
1986248 | F
2047654 | F
2048191 | F
2120783 | F
2128458 | F
2128569 | F
2293622 | F
2294053 | F
2294206 | F
2295868 | 00
2297592 | F
2298038 | F
2298490 | F
2298621 | F
2298654 | F
2298881 | F
2300197 | 00
2300346 | 00
2424411 | F
2473330 | 00
2473555 | 00
2473933 | F
2475193 | F
2475465 | F
2476540 | 00
2476691 | 00
2524038 | F
2853656 | 00
2884544 | F
2913959 | 00

# IfcFlowFitting: NLRS_52_PIF_UN_PVC verloop LV_SH_Dyka:Grijs, var. DN/OD (nested) (130)
Type - Description: Dyka Reducer; PredefinedType: TRANSITION; Classification: 52 (Uniformat); Material: NLRS_n6_PVC_grijs_Dyka (2)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dyka
Type - Pset_ProductRequirements - Category: Pipe Fittings
Pset_DistributionFlowElementCommon - Reference: Grijs, var. DN/OD (nested); sets with these values: 2
Name (NLRS_52_PIF_UN_PVC verloop LV_SH_Dyka:Grijs, var. DN/OD (nested):...) | In | Material
1409141 | 01
1410152 | 01
1410204 | 01 | NLRS_n6_PVC_grijs_Dyka
1410222 | 01 | NLRS_n6_PVC_grijs_Dyka
1410242 | 01 | NLRS_n6_PVC_grijs_Dyka
1410262 | 01 | NLRS_n6_PVC_grijs_Dyka
1410298 | 01 | NLRS_n6_PVC_grijs_Dyka
1410329 | 01 | NLRS_n6_PVC_grijs_Dyka
1411391 | 01 | NLRS_n6_PVC_grijs_Dyka
1411399 | 01 | NLRS_n6_PVC_grijs_Dyka
1411407 | 01 | NLRS_n6_PVC_grijs_Dyka
1411415 | 01 | NLRS_n6_PVC_grijs_Dyka
1411423 | 01 | NLRS_n6_PVC_grijs_Dyka
1414212 | 01 | NLRS_n6_PVC_grijs_Dyka
1414227 | 01 | NLRS_n6_PVC_grijs_Dyka
1546239 | 01 | NLRS_n6_PVC_grijs_Dyka
1546400 | 01 | NLRS_n6_PVC_grijs_Dyka
1551876 | 00
1552052 | 00
1617660 | 00 | NLRS_n6_PVC_grijs_Dyka
1618085 | 00 | NLRS_n6_PVC_grijs_Dyka
1618177 | 00 | NLRS_n6_PVC_grijs_Dyka
1618217 | 00 | NLRS_n6_PVC_grijs_Dyka
1618307 | 00 | NLRS_n6_PVC_grijs_Dyka
1618315 | 00 | NLRS_n6_PVC_grijs_Dyka
1618323 | 00 | NLRS_n6_PVC_grijs_Dyka
1618438 | 00 | NLRS_n6_PVC_grijs_Dyka
1618467 | 00 | NLRS_n6_PVC_grijs_Dyka
1619046 | 00 | NLRS_n6_PVC_grijs_Dyka
1694188 | 00 | NLRS_n6_PVC_grijs_Dyka
1695670 | 00
1941909 | 00
1942214 | 00 | NLRS_n6_PVC_grijs_Dyka
1968763 | 00 | NLRS_n6_PVC_grijs_Dyka
1969564 | 00
1969832 | 00 | NLRS_n6_PVC_grijs_Dyka
1970131 | 00 | NLRS_n6_PVC_grijs_Dyka
1970155 | F | NLRS_n6_PVC_grijs_Dyka
1970329 | 00 | NLRS_n6_PVC_grijs_Dyka
1973392 | F | NLRS_n6_PVC_grijs_Dyka
1973555 | F | NLRS_n6_PVC_grijs_Dyka
1973608 | F | NLRS_n6_PVC_grijs_Dyka
1975666 | F | NLRS_n6_PVC_grijs_Dyka
1976846 | F | NLRS_n6_PVC_grijs_Dyka
1981530 | 00 | NLRS_n6_PVC_grijs_Dyka
1982487 | F | NLRS_n6_PVC_grijs_Dyka
1982587 | F | NLRS_n6_PVC_grijs_Dyka
1986065 | F | NLRS_n6_PVC_grijs_Dyka
1986250 | F | NLRS_n6_PVC_grijs_Dyka
2047606 | 00 | NLRS_n6_PVC_grijs_Dyka
2047656 | F | NLRS_n6_PVC_grijs_Dyka
2047961 | 00 | NLRS_n6_PVC_grijs_Dyka
2048193 | F | NLRS_n6_PVC_grijs_Dyka
2048231 | 00 | NLRS_n6_PVC_grijs_Dyka
2120251 | 00 | NLRS_n6_PVC_grijs_Dyka
2120785 | F | NLRS_n6_PVC_grijs_Dyka
2120903 | 00 | NLRS_n6_PVC_grijs_Dyka
2122104 | 00 | NLRS_n6_PVC_grijs_Dyka
2122112 | 00 | NLRS_n6_PVC_grijs_Dyka
2122505 | 00 | NLRS_n6_PVC_grijs_Dyka
2128460 | F | NLRS_n6_PVC_grijs_Dyka
2128475 | 00 | NLRS_n6_PVC_grijs_Dyka
2128577 | F | NLRS_n6_PVC_grijs_Dyka
2288460 | F | NLRS_n6_PVC_grijs_Dyka
2293624 | F | NLRS_n6_PVC_grijs_Dyka
2293949 | 00 | NLRS_n6_PVC_grijs_Dyka
2294055 | F | NLRS_n6_PVC_grijs_Dyka
2294209 | F | NLRS_n6_PVC_grijs_Dyka
2294339 | 00 | NLRS_n6_PVC_grijs_Dyka
2295870 | 00 | NLRS_n6_PVC_grijs_Dyka
2296532 | 00 | NLRS_n6_PVC_grijs_Dyka
2296896 | 00 | NLRS_n6_PVC_grijs_Dyka
2297557 | 00 | NLRS_n6_PVC_grijs_Dyka
2297594 | F | NLRS_n6_PVC_grijs_Dyka
2297855 | 00 | NLRS_n6_PVC_grijs_Dyka
2298040 | F | NLRS_n6_PVC_grijs_Dyka
2298177 | F | NLRS_n6_PVC_grijs_Dyka
2298492 | F | NLRS_n6_PVC_grijs_Dyka
2298623 | F | NLRS_n6_PVC_grijs_Dyka
2298656 | F | NLRS_n6_PVC_grijs_Dyka
2298778 | F | NLRS_n6_PVC_grijs_Dyka
2298789 | F | NLRS_n6_PVC_grijs_Dyka
2298883 | F | NLRS_n6_PVC_grijs_Dyka
2298918 | F | NLRS_n6_PVC_grijs_Dyka
2300205 | 00 | NLRS_n6_PVC_grijs_Dyka
2300348 | 00 | NLRS_n6_PVC_grijs_Dyka
2424413 | F | NLRS_n6_PVC_grijs_Dyka
2473332 | 00 | NLRS_n6_PVC_grijs_Dyka
2473557 | 00 | NLRS_n6_PVC_grijs_Dyka
2473941 | F | NLRS_n6_PVC_grijs_Dyka
2475195 | F | NLRS_n6_PVC_grijs_Dyka
2475467 | F | NLRS_n6_PVC_grijs_Dyka
2476542 | 00 | NLRS_n6_PVC_grijs_Dyka
2476693 | 00 | NLRS_n6_PVC_grijs_Dyka
2479720 | 00 | NLRS_n6_PVC_grijs_Dyka
2480868 | 01 | NLRS_n6_PVC_grijs_Dyka
2524040 | F | NLRS_n6_PVC_grijs_Dyka
2552913 | 00 | NLRS_n6_PVC_grijs_Dyka
2567959 | 01
2818382 | 00 | NLRS_n6_PVC_grijs_Dyka
2821168 | 01
2821205 | 01 | NLRS_n6_PVC_grijs_Dyka
2821239 | 01 | NLRS_n6_PVC_grijs_Dyka
2821275 | 01 | NLRS_n6_PVC_grijs_Dyka
2821311 | 01 | NLRS_n6_PVC_grijs_Dyka
2825808 | 01 | NLRS_n6_PVC_grijs_Dyka
2825877 | 01 | NLRS_n6_PVC_grijs_Dyka
2826000 | 01 | NLRS_n6_PVC_grijs_Dyka
2826039 | 01 | NLRS_n6_PVC_grijs_Dyka
2826082 | 01 | NLRS_n6_PVC_grijs_Dyka
2853658 | 00
2884546 | F
2885159 | 01 | NLRS_n6_PVC_grijs_Dyka
2885868 | 01 | NLRS_n6_PVC_grijs_Dyka
2885896 | 01 | NLRS_n6_PVC_grijs_Dyka
2885922 | 01 | NLRS_n6_PVC_grijs_Dyka
2886417 | 01 | NLRS_n6_PVC_grijs_Dyka
2886449 | 01 | NLRS_n6_PVC_grijs_Dyka
2892789 | F | NLRS_n6_PVC_grijs_Dyka
2892930 | F | NLRS_n6_PVC_grijs_Dyka
2892956 | F | NLRS_n6_PVC_grijs_Dyka
2892982 | F | NLRS_n6_PVC_grijs_Dyka
2893008 | F | NLRS_n6_PVC_grijs_Dyka
2905060 | F
2913843 | 01 | NLRS_n6_PVC_grijs_Dyka
2913961 | 00 | NLRS_n6_PVC_grijs_Dyka
2913967 | 00 | NLRS_n6_PVC_grijs_Dyka
2914377 | 00 | NLRS_n6_PVC_grijs_Dyka
2914660 | 00 | NLRS_n6_PVC_grijs_Dyka
2917628 | 01 | NLRS_n6_PVC_grijs_Dyka

# IfcFlowFitting: NLRS_57_DF_UN_splitsingsflens_generiek:NLRS_57_DF_UN_splitsingsflens_generiek (13)
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: NLRS_57_DF_UN_splitsingsflens_generiek; sets with these values: 2
Name (NLRS_57_DF_UN_splitsingsflens_generiek:NLRS_57_DF_UN_splitsingsflens_generiek:...) | In | Group
1822750 | 00 | mvt lbk1
1831419 | 00 | mvr 5
1874448 | 00 | mvr 5
2009998 | 01 | mvt lbk1
2028866 | 01 | mvr 5
2030289 | 01 | mvr 5
2111932 | 00 | mvt lbk1
2159093 | 00 | mvr 5
2303742 | 00 | mvr 5
2487429 | 01 | mvt 2
2625153 | 01 | mvr 5
2696364 | 01 | mvr 5
2707063 | 01 | mvt lbk1

# IfcFlowFitting: NLRS_57_DUF_UN_rechth deksel_Luka:verzinkt_staal, NLRS_57_DUF_UN_rechth deksel_Luka:verzinkt_staal:2565070
In: 01
Type - Description: Rechthoekig - deksel; PredefinedType: USERDEFINED; Classification: 57.5 (Uniformat); Material: NLRS_A_staal Sendzimir verzinkt
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: verzinkt_staal; sets with these values: 2
Group: mvaf 3

# IfcFlowFitting: NLRS_57_DUF_UN_rechth splitsing-a_Luka:stromend ri=150, NLRS_57_DUF_UN_rechth splitsing-a_Luka:stromend ri=150:2004327
In: 01
Type - Description: Rechthoekig - splitsing geschaard, variabel aftakkend; PredefinedType: JUNCTION; Classification: 57.5 (Uniformat); Material: NLRS_A_staal Sendzimir verzinkt
Type - Pset_ManufacturerTypeInformation - Manufacturer: Luka
Type - Pset_ProductRequirements - Category: Duct Fittings
Pset_DistributionFlowElementCommon - Reference: stromend ri=150; sets with these values: 2
Group: mvt lbk1

# IfcFlowFitting: NLRS_60_CF_UN_invoerbocht_gen:standaard (232)
In: F
Type - Material: <Unnamed>
Type - Pset_ProductRequirements - Category: Conduit Fittings
Pset_DistributionFlowElementCommon - Reference: standaard; sets with these values: 2
Name (NLRS_60_CF_UN_invoerbocht_gen:standaard:...)
2648415
2648430
2648433
2648439
2648451
2648463
2648469
2648475
2648478
2648481
2648484
2648487
2648496
2648499
2648502
2648511
2658226
2659935
2660794
2660833
2660872
2662215
2662361
2662896
2664358
2664361
2669282
2836572
2837004
2837517
2837520
2837525
2837680
2837710
2837819
2837859
2837869
2837919
2837922
2837990
2838061
2838071
2838157
2838163
2838245
2838352
2838357
2838386
2838419
2838447
2838480
2838614
2838617
2838622
2838775
2838914
2839130
2839132
2839135
2839424
2839432
2839473
2839484
2839595
2839630
2839638
2839641
2839750
2839763
2839798
2839812
2839913
2839923
2839951
2839961
2840019
2840070
2840218
2840229
2840232
2840473
2840529
2840610
2840668
2840671
2840747
2840783
2840786
2840860
2841153
2841187
2841189
2841856
2841859
2841890
2842238
2842728
2842772
2842804
2842833
2842981
2842986
2843448
2845563
2846497
2846677
2847377
2847388
2847423
2847432
2847491
2847494
2895176
2895179
2895196
2895199
2895206
2895209
2895217
2895223
2895519
2895532
2895534
2895536
2895539
2895587
2895589
2895656
2895757
2895857
2895859
2895879
2895881
2896021
2896023
2896143
2896145
2896165
2896167
2896225
2896227
2896251
2896293
2896296
2896299
2896302
2896573
2896575
2896580
2896583
2896669
2896671
2896780
2896782
2896950
2896993
2896995
2897012
2897742
2897771
2897863
2897892
2897968
2898060
2898121
2898230
2898387
2898650
2898802
2898805
2898930
2899150
2899285
2899622
2899625
2899706
2899709
2899714
2899717
2899738
2899741
2899745
2900734
2900857
2900959
2900962
2901036
2901071
2901204
2901208
2901287
2901321
2901351
2901354
2901404
2901485
2901560
2901563
2901591
2901683
2901686
2901728
2901731
2901844
2901847
2901873
2902079
2902101
2902104
2902127
2902130
2902135
2902241
2902244
2902395
2902430
2902433
2902436
2902479
2902536
2902547
2902595
2902599
2902649
2902658
2902695
2902744
2902748
2902779
2902886
2902944
2902948

# IfcFlowSegment: Conduit without Fittings:Bronnen (282)
In: F
Type - PredefinedType: CONDUITSEGMENT
Type - Pset_ProductRequirements - Category: Conduits
Pset_DistributionFlowElementCommon - Reference: Bronnen; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Conduit without Fittings:Bronnen:...) | Length (mm)
2646691 | 38
2646947 | 374.225
2646955 | 268
2646987 | 268
2646995 | 268
2647003 | 268
2647011 | 268
2647019 | 268
2647027 | 268
2647029 | 3227.69
2647035 | 268
2647043 | 268
2647051 | 268
2647059 | 268
2647067 | 268
2647075 | 268
2647083 | 268
2647091 | 268
2647099 | 268
2647107 | 268
2647115 | 268
2647123 | 268
2647158 | 268
2647582 | 38
2647614 | 38
2647622 | 38
2647630 | 38
2647638 | 38
2647646 | 38
2647654 | 38
2647662 | 38
2647663 | 2703.42
2647670 | 38
2647678 | 38
2647686 | 38
2647694 | 38
2647695 | 7787.1
2647702 | 38
2647710 | 38
2647718 | 38
2647726 | 38
2647734 | 38
2647742 | 38
2647750 | 38
2652672 | 144.225
2657534 | 2677.71
2657926 | 2104.72
2657984 | 2004.72
2658210 | 1829.18
2658655 | 4385.45
2659558 | 268
2659560 | 38
2659706 | 268
2659708 | 38
2659879 | 268
2659880 | 38
2661073 | 2803.42
2662063 | 7787.1
2664349 | 268
2664354 | 38
2664918 | 4577.35
2664956 | 4477.35
2669201 | 1383.97
2669267 | 1283.97
2834956 | 2073.12
2834965 | 2108.38
2835074 | 1946.08
2835076 | 2180.34
2835078 | 2215.6
2835084 | 2407.09
2836975 | 1847.95
2837378 | 8608.87
2837432 | 10139.8
2837479 | 14830.9
2837803 | 1533.56
2837809 | 1379.8
2837822 | 10139.8
2837845 | 1258.82
2837851 | 1672.18
2837971 | 1741.73
2837992 | 2180.7
2837998 | 14830.9
2838045 | 1527.28
2838053 | 2417.32
2838237 | 2266.04
2838270 | 2345.49
2838370 | 1532.52
2838378 | 808.566
2838432 | 1905.73
2838449 | 422.196
2838520 | 4257.35
2838522 | 4398.77
2838546 | 9657.35
2838548 | 9798.77
2838943 | 3127.69
2839096 | 8247.46
2839334 | 9280.62
2839408 | 2521.28
2839416 | 805.494
2839457 | 2521.28
2839465 | 687.184
2839578 | 20461.7
2839587 | 332.253
2839614 | 20561.7
2839622 | 213.943
2839734 | 19862.4
2839742 | 337.834
2839752 | 2486.2
2839776 | 20295.9
2839784 | 306.125
2839801 | 2212.7
2839899 | 19292.4
2839907 | 257.211
2839915 | 2512.74
2839937 | 19292.4
2839945 | 450.397
2839953 | 2326.14
2840003 | 9398.6
2840052 | 1223.14
2840202 | 2593.69
2840210 | 1029.95
2840246 | 2563.04
2840290 | 2649.64
2840336 | 732.476
2840477 | 8608.87
2840543 | 632.476
2840701 | 2278.04
2840709 | 1132.48
2840733 | 2364.64
2840820 | 1032.48
2840828 | 8247.46
2840959 | 1793.25
2841073 | 1883.3
2841142 | 271.638
2841156 | 582.808
2841301 | 4492.69
2842218 | 1897.82
2842230 | 7913.18
2842276 | 1797.82
2842284 | 8054.6
2842398 | 1329.92
2842427 | 1246.01
2842712 | 1898.04
2842756 | 2158.04
2842788 | 1532.08
2842819 | 1432.08
2842908 | 1476.6
2842916 | 4187.24
2842941 | 1270.99
2842949 | 4087.85
2843287 | 5428.75
2843339 | 5557.31
2843469 | 6121.33
2843508 | 5948.12
2845587 | 994.807
2845617 | 994.807
2845673 | 1701.19
2845728 | 1701.19
2846744 | 2577.71
2847369 | 1999.67
2847415 | 1858.24
2847703 | 1729.18
2848108 | 2563.91
2895163 | 309.527
2895164 | 208.802
2895165 | 185.967
2895166 | 22.1995
2895167 | 99.3648
2895169 | 318.27
2895172 | 446.901
2895173 | 464.461
2895181 | 3321.83
2895188 | 573.262
2895191 | 419.232
2895194 | 766.447
2895195 | 232.629
2895202 | 1346
2895205 | 1539.19
2895216 | 796.076
2895220 | 896.076
2895396 | 1753.89
2895419 | 1953.89
2895547 | 3166.82
2895623 | 4932.32
2895631 | 8173.68
2895685 | 1683.19
2895741 | 4813.15
2895749 | 8329.25
2895759 | 1683.19
2895915 | 7478.15
2895916 | 7347.61
2895928 | 4869.55
2895929 | 4869.55
2896038 | 1038.02
2896088 | 1038.02
2896116 | 1200.81
2896117 | 1200.81
2896618 | 5376.92
2896627 | 2170.68
2896695 | 6576.04
2896704 | 2271.24
2896817 | 7677.42
2896826 | 1711.2
2896881 | 7824.05
2896890 | 1814.2
2897055 | 694.83
2897071 | 761.628
2897073 | 848.23
2897076 | 781.432
2897078 | 395.929
2897080 | 304.095
2897629 | 10548.5
2897632 | 10248.5
2897634 | 10348.5
2897662 | 9349.36
2897663 | 9349.36
2897921 | 1177.34
2897954 | 1077.34
2897962 | 5656.29
2898081 | 5514.87
2898216 | 2248.01
2898224 | 1869.85
2898249 | 2248.01
2898257 | 1969.85
2898282 | 6535.28
2898283 | 6535.28
2898284 | 5955.67
2898286 | 5955.67
2898288 | 6894.55
2898697 | 10648.5
2898829 | 8565.16
2898863 | 3448.53
2898898 | 3448.53
2898978 | 12394
2898992 | 23881.2
2899170 | 2422.49
2899328 | 2683.06
2899338 | 12394
2899389 | 2683.06
2900463 | 12720.4
2900470 | 1445.98
2900512 | 12579.5
2900566 | 18490.7
2900575 | 946.076
2900624 | 18632.1
2900631 | 1046.08
2900843 | 395.929
2900895 | 304.095
2900901 | 1531.31
2901020 | 694.83
2901057 | 781.432
2901273 | 1171.44
2901307 | 1258.04
2901313 | 546.076
2901378 | 24022.6
2901387 | 646.076
2901469 | 1638.04
2901477 | 146.076
2901516 | 1551.44
2901605 | 246.076
2901690 | 1550.54
2901691 | 1046.08
2901692 | 946.076
2901693 | 1445.98
2901698 | 646.076
2901700 | 546.076
2902465 | 980.225
2902482 | 191.22
2902490 | 7040.97
2902518 | 1034.82
2902528 | 295.784
2902633 | 1212.43
2902639 | 90.299
2902681 | 1235.05
2902687 | 283.484
2902698 | 8455.93
2902763 | 2098.98
2902769 | 98.9851
2902782 | 11903.4
2902811 | 2121.22
2902900 | 90.299
2902909 | 12011.7

# IfcFlowSegment: Flex Duct Round:Flex - Round (188)
Type - PredefinedType: FLEXIBLESEGMENT
Type - Pset_ElementShading - Roughness: 0.09144 mm
Type - Pset_ProductRequirements - Category: Flex Ducts
Pset_DistributionFlowElementCommon - Reference: Flex - Round; sets with these values: 2
Pset_DuctSegmentTypeCommon - sets with these values: 3
Name (Flex Duct Round:Flex - Round:...) | In | Length (mm) | Group
1496878 | 00 | 882.373 | mvr 5
1496880 | 00 | 882.373 | mvr 5
1496882 | 00 | 882.373 | mvr 5
1496884 | 00 | 782.716 | mvr 5
1496886 | 00 | 782.716 | mvr 5
1496888 | 00 | 782.716 | mvr 5
1658918 | 00 | 928.64 | mvt lbk1
1658922 | 00 | 928.64 | mvt lbk1
1659173 | 00 | 1009.56 | mvt lbk1
1660891 | 00 | 1016.7 | mvt lbk1
1660893 | 00 | 1016.7 | mvt lbk1
1660997 | 00 | 1016.7 | mvt lbk1
1660999 | 00 | 1016.7 | mvt lbk1
1666534 | 00 | 1016.7 | mvt lbk1
1666536 | 00 | 1016.7 | mvt lbk1
1674424 | 00 | 1104.97 | mvt lbk1
1674426 | 00 | 1104.97 | mvt lbk1
1721744 | 00 | 1016.7 | mvt lbk1
1721746 | 00 | 1016.7 | mvt lbk1
1722192 | 00 | 1016.7 | mvt lbk1
1722194 | 00 | 1016.7 | mvt lbk1
1722574 | 00 | 1016.7 | mvt lbk1
1722576 | 00 | 1016.7 | mvt lbk1
1726210 | 00 | 1006.28 | mvt lbk1
1726212 | 00 | 1006.28 | mvt lbk1
1800661 | 01 | 1022.57 | mvr 5
1914032 | 00 | 1007.19 | mvt lbk1
1914034 | 00 | 1007.19 | mvt lbk1
1938023 | 00 | 926.338 | mvr 5
1938853 | 00 | 824.063 | mvr 5
1940396 | 00 | 1000.05 | mvr 5
1948847 | 00 | 903.065 | mvr 5
1953383 | 00 | 639.819 | mvr 5
1953385 | 00 | 740.142 | mvr 5
1953387 | 00 | 775.553 | mvr 5
1953389 | 00 | 775.553 | mvr 5
1953391 | 00 | 715.686 | mvr 5
1953877 | 00 | 1003.37 | mvr 5
1953879 | 00 | 1003.37 | mvr 5
1956017 | 00 | 903.649 | mvr 5
1958289 | 00 | 1003.37 | mvr 5
1958444 | 00 | 871.175 | mvr 5
1962789 | 00 | 959.682 | mvr 5
1962791 | 00 | 959.682 | mvr 5
1962793 | 00 | 959.682 | mvr 5
1963365 | 00 | 946.811 | mvr 5
1998270 | 01 | 706.007 | mvr 5
1998275 | 01 | 673.723 | mvr 5
