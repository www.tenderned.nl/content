Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: C:/Dummy_IFC_Filepath.ifc
Time: 2024-10-25T11:23:06
Author: KlimaSoft User, info@softsolutions.de
Organization: AL-KO
Written by: IFC-Engine V 1.0
Made in: IFC-Engine
Authorization: AL-KO Klim@Soft

# IfcProject, Default Project
Description: Description of Default Project
AT4-F 20x20/20x20 - Wetterfest - Aufstellung: Außenraum; Preis: 63000 eur; Gewicht: 5188.55 kg; Breite: 3.2325 m; Höhe: 2.32825 m; Länge: 9.2565 m; Eurovent: B; ERP: Konform 2018; WRG Gesamtleistung: 194.955 W; WRG Wirkungsgrad Zuluft: 73.9674; Kühler Leistung: 64.8077 W; Kühler Temperatur Medium Eingang: 12; Kühler Temperatur Medium Ausgang: 18; Erhitzer Leistung: 42.6047 W; Erhitzer Temperatur Medium Eingang: 45; Erhitzer Temperatur Medium Ausgang: 35; Ventilator Nennleistung Abluft: 7.5 W; Ventilator Typ Abluft: AV-Ventilator; Ventilator Nennleistung Zuluft: 7.5 W; Ventilator Typ Zuluft: AV-Ventilator; Zuluftfilter Stufe 1: F7; Zuluftfilter Stufe 2: F7; Abluftfilter Stufe: F5; Zuluft Volumenstrom: 18000 m3/s; Zuluft Druck: 400 Pa; Abluft Volumenstrom: 18000 m3/s; Abluft Druck: 400 Pa

# IfcBuilding, RLT
Description: Description

# IfcBuildingElementProxy (16)
In: RLT
Name
8 x Kammern Gehäuse | Description: Description
8 x Kammer Rahmen

# IfcBuildingElementProxy: ControlElement (8)
In: RLT
Description: Rahmen der Gehäuse separiert

# IfcDiscreteAccessory: Zubehör (6)
In: RLT
Type - Description: Zubehör
Group: Kammer

# IfcElementAssembly (8)
In: RLT
Description: Description; PredefinedType: RIGID_FRAME; Group: Kammer
Name
Kammer Komponenten | Filter Eigenschaften - Herstellertyp: KS50-L; Klasse: ePM10-55 % / M5; Eff. Klasse: E; Wartung: F - Schnellspann.; Auslegungsdruck: 67 Pa; Schalldämpfer Eigenschaften - Schalldämpferlänge: 918 mm; Stutzen Eigenschaften - Typ: Entkopplungsstutzen; Breite: 1.530 mm; Höhe: 1.530 mm; Material: Gummi
Kammer Komponenten | Schalldämpfer Eigenschaften - Schalldämpferlänge: 918 mm; Ventilator Eigenschaften - # Einheiten: 1; Herstellertyp: RLM EVO; Volumenstrom: 18.000 m³/h; stat. Druckerhöhung: 694 Pa; Gehäusewiderstand: 20 Pa; Wellenleistung: 4,51 kW; stat. Wirkungsgrad: 77 %; tot. Wirkungsgrad: 81 %; Betriebsdrehzahl: 1.048 1/min; Belastungsgrenze: 1.670 1/min; Baugröße: 132; Regelungsart: FU; Betriebsfrequenz: 35 Hz; Max. Frequenz: 38 Hz; Volumen-/Drehzahl-Reserve: 8 %; Leistung PM: 4,99 kW; Leistung PM-FU: 5,52 kW; IE2: 1; Wirkungsgradklasse: IE 3; SFP Wert (GEG 2020): 751 W/(m³/s); SFPv (EN 16798-3): 1.051 W/(m³/s); SFP Klasse (EN 16798-3): SFP 3; Geschw.-Klasse (EN13053): V4; Nenn-Spannung: 400/690 V; Netzfrequenz: 50 Hz; Nennleistung(en): 7,5 kW; Nennstrom: 14,3/ 8,3 A; Nenndrehzahl(en): 1470 /min; Schutzklasse: IP55; Überlastsicherung: Kaltleiter; Isolationsklasse: F; P Klasse: P1; Systemwirkungsgrad: 61 %; Buchsen-Nummer: 2012; Ø Buchse: 38 mm; Schallleistungspegel Eintritt: 77,0 dB(A); Schallleistungspegel Austritt: 81,6 dB(A)
Kammer Komponenten | Filter Eigenschaften - Herstellertyp: NW85-L; Klasse: ePM1-60 % / F7; Eff. Klasse: A; Wartung: F - Schnellspann.; Auslegungsdruck: 108 Pa; Stutzen Eigenschaften - Typ: Lamellenhaube; Breite: 20 AT4 Raster; Höhe: 20 AT4 Raster; Gesamtdrehmoment: 15,00 Nm
Kammer Komponenten | Schalldämpfer Eigenschaften - Schalldämpferlänge: 918 mm; Ventilator Eigenschaften - # Einheiten: 1; Herstellertyp: RLM EVO; Volumenstrom: 18.000 m³/h; stat. Druckerhöhung: 1.022 Pa; Gehäusewiderstand: 30 Pa; Wellenleistung: 6,67 kW; stat. Wirkungsgrad: 77 %; tot. Wirkungsgrad: 81 %; Betriebsdrehzahl: 1.479 1/min; Belastungsgrenze: 1.880 1/min; Baugröße: 132; Regelungsart: FU; Betriebsfrequenz: 50 Hz; Max. Frequenz: 52 Hz; Volumen-/Drehzahl-Reserve: 4 %; Leistung PM: 7,38 kW; Leistung PM-FU: 7,79 kW; IE2: 1; Wirkungsgradklasse: IE 3; SFP Wert (GEG 2020): 1.106 W/(m³/s); SFPv (EN 16798-3): 1.406 W/(m³/s); SFP Klasse (EN 16798-3): SFP 3; Geschw.-Klasse (EN13053): V4; Nenn-Spannung: 400/690 V; Netzfrequenz: 50 Hz; Nennleistung(en): 7,5 kW; Nennstrom: 14,3/ 8,3 A; Nenndrehzahl(en): 1470 /min; Schutzklasse: IP55; Überlastsicherung: Kaltleiter; Isolationsklasse: F; P Klasse: P1; Systemwirkungsgrad: 64 %; Buchsen-Nummer: 2012; Ø Buchse: 38 mm; Schallleistungspegel Eintritt: 81,8 dB(A); Schallleistungspegel Austritt: 86,6 dB(A)
Kammer Komponenten | Stutzen Eigenschaften - Typ: Klappe, innen; Breite: 1.341,0 mm; Höhe: 1.453 mm; Gesamtdrehmoment: 15,00 Nm
Kammer Komponenten | Filter Eigenschaften - Herstellertyp: NW85-L; Klasse: ePM1-60 % / F7; Eff. Klasse: A; Wartung: S - staubluftseitig; Auslegungsdruck: 108 Pa; Stutzen Eigenschaften - Typ: Entkopplungsstutzen; Breite: 1.530 mm; Höhe: 1.530 mm; Material: Gummi
Kammer Komponenten | Wärmetauscher Eigenschaften - Typ: Sorption; Ges. Wärmeleistung: 195,0 kW; Rückwärmzahl: 74,0 %; Rückfeuchtzahl: 71,5 %; WRG-Klasse (EN 13053/2020): H2; Wirkungsgrad (ausgegl., trocken): 74,0 %; Betriebszustand: 1; Δ Druck (Z): 143,3 Pa; Temperatur IN: -10,0 °C; Rel. Feuchte IN: 60,0 %; Abs. Feuchte IN: 1,0 g/kgL; Temperatur OUT: 12,9 °C; Rel. Feuchte OUT: 50,8 %; Abs. Feuchte OUT: 4,7 g/kgL
Kammer Komponenten | Schalldämpfer Eigenschaften - Schalldämpferlänge: 918 mm; Wärmetauscher Eigenschaften - Ges. Wärmeleistung: 64,81 kW; Luftwiderstand (trocken): 105 Pa; Luftgeschwindigkeit: 2,57 m/s; Eintrittstemperatur: 26,6 °C; Relative Eintrittsfeuchte: 55,8 %; Abs. Eintrittsfeuchte: 12,2 g/kgL; Austrittstemperatur: 17,0 °C; Rel. Austrittsfeuchte: 97 %; Abs. Austrittsfeuchte: 11,8 g/kgL; Leistungsreserve: 35 %; Volumenstrom: 18.000 m³/h; Medium Eintrittstemperatur: 12,0 °C; Medium Austrittstemperatur: 18,0 °C; Max. Betriebsdruck: 16 bar; Mediumwiderstand: 7 kPa; Füllmenge: 58,3 l; Umwälzmenge: 9.274 l/h; Medium: Wasser; Glykol Anteil: 0 %; Rohre: Cu; Rohrreihen: 8; Kreise: 76; Lamellen: Al; Δ Lamellen: 2,5 mm; Sammler: Cu; Rahmen: Al; Einbausatz: Edelstahl (1.4301); Anschlüsse pro Kreislauf: 2; Anschlussweite: DN 80 (R 3); Anschlussart: A - gerade; Frostschutzrahmen: ohne; Beschreibung: Tr_UL_Cooler

# IfcEnergyConversionDevice: Wärmetauscher (3)
In: RLT
Type - Description: Wärmetauscher
Group: Kammer
Name | Ges. Wärmeleistung | Luftwiderstand (trocken) | Luftgeschwindigkeit | Eintrittstemperatur | Relative Eintrittsfeuchte | Abs. Eintrittsfeuchte | Austrittstemperatur | Rel. Austrittsfeuchte | Abs. Austrittsfeuchte | Leistungsreserve | Volumenstrom | Medium Eintrittstemperatur | Medium Austrittstemperatur | Max. Betriebsdruck | Mediumwiderstand | Füllmenge | Umwälzmenge | Medium | Glykol Anteil | Rohre = Sammler | Rohrreihen | Kreise | Lamellen = Rahmen | Δ Lamellen | Einbausatz | Anschlüsse pro Kreislauf | Anschlussweite | Anschlussart | Frostschutzrahmen | Beschreibung
Wärmetauscher | 195,0 kW | Wärmetauscher Eigenschaften - Typ: Sorption; Rückwärmzahl: 74,0 %; Rückfeuchtzahl: 71,5 %; WRG-Klasse (EN 13053/2020): H2; Wirkungsgrad (ausgegl., trocken): 74,0 %; Betriebszustand: 1; Δ Druck (Z): 143,3 Pa; Temperatur IN: -10,0 °C; Rel. Feuchte IN: 60,0 %; Abs. Feuchte IN: 1,0 g/kgL; Temperatur OUT: 12,9 °C; Rel. Feuchte OUT: 50,8 %; Abs. Feuchte OUT: 4,7 g/kgL
Wärmetauscher | 64,81 kW | 105 Pa | 2,57 m/s | 26,6 °C | 55,8 % | 12,2 g/kgL | 17,0 °C | 97 % | 11,8 g/kgL | 35 % | 18.000 m³/h | 12,0 °C | 18,0 °C | 16 bar | 7 kPa | 58,3 l | 9.274 l/h | Wasser | 0 % | Cu | 8 | 76 | Al | 2,5 mm | Edelstahl (1.4301) | 2 | DN 80 (R 3) | A - gerade | ohne | Tr_UL_Cooler
Wärmetauscher | 42,60 kW | 46 Pa | 2,54 m/s | 12,9 °C | 50,8 % | 4,7 g/kgL | 20,0 °C | 32 % | 4,7 g/kgL | 165 % | 18.000 m³/h | 45,0 °C | 35,0 °C | 16 bar | 2 kPa | 26,4 l | 3.694 l/h | Wasser | 0 % | Cu | 3 | 43 | Al | 2,1 mm | FeZn | 2 | DN 65 (R 2-1/2) | A - gerade | ohne | Tr_UL_Heater

# IfcFlowMovingDevice: Ventilator (2)
In: RLT
Type - Description: Ventilator
Ventilator Eigenschaften - # Einheiten: 1; Herstellertyp: RLM EVO; Volumenstrom: 18.000 m³/h; stat. Wirkungsgrad: 77 %; tot. Wirkungsgrad: 81 %; Baugröße: 132; Regelungsart: FU; IE2: 1; Wirkungsgradklasse: IE 3; SFP Klasse (EN 16798-3): SFP 3; Geschw.-Klasse (EN13053): V4; Nenn-Spannung: 400/690 V; Netzfrequenz: 50 Hz; Nennleistung(en): 7,5 kW; Nennstrom: 14,3/ 8,3 A; Nenndrehzahl(en): 1470 /min; Schutzklasse: IP55; Überlastsicherung: Kaltleiter; Isolationsklasse: F; P Klasse: P1; Buchsen-Nummer: 2012; Ø Buchse: 38 mm
Group: Kammer
Name | stat. Druckerhöhung | Gehäusewiderstand | Wellenleistung | Betriebsdrehzahl | Belastungsgrenze | Betriebsfrequenz | Max. Frequenz | Volumen-/Drehzahl-Reserve | Leistung PM | Leistung PM-FU | SFP Wert (GEG 2020) | SFPv (EN 16798-3) | Systemwirkungsgrad | Schallleistungspegel Eintritt | Schallleistungspegel Austritt
Ventilator | 694 Pa | 20 Pa | 4,51 kW | 1.048 1/min | 1.670 1/min | 35 Hz | 38 Hz | 8 % | 4,99 kW | 5,52 kW | 751 W/(m³/s) | 1.051 W/(m³/s) | 61 % | 77,0 dB(A) | 81,6 dB(A)
Ventilator | 1.022 Pa | 30 Pa | 6,67 kW | 1.479 1/min | 1.880 1/min | 50 Hz | 52 Hz | 4 % | 7,38 kW | 7,79 kW | 1.106 W/(m³/s) | 1.406 W/(m³/s) | 64 % | 81,8 dB(A) | 86,6 dB(A)

# IfcFlowTerminal: Stutzen (6)
In: RLT
Type - Description: Stutzen
Group: Kammer
Name | Typ | Breite | Höhe
2 x Stutzen | Entkopplungsstutzen | 1.530 mm | 1.530 mm | Stutzen Eigenschaften - Material: Gummi
2 x Stutzen | Lamellenhaube | 20 AT4 Raster | 20 AT4 Raster
2 x Stutzen | Klappe, innen | 1.341,0 mm | 1.453 mm | Stutzen Eigenschaften - Gesamtdrehmoment: 15,00 Nm

# IfcFlowTreatmentDevice: Filter (3)
In: RLT
Type - Description: Filter
Group: Kammer
Name | Herstellertyp | Klasse | Eff. Klasse | Wartung | Auslegungsdruck
Filter | KS50-L | ePM10-55 % / M5 | E | F - Schnellspann. | 67 Pa
Filter | NW85-L | ePM1-60 % / F7 | A | F - Schnellspann. | 108 Pa
Filter | NW85-L | ePM1-60 % / F7 | A | S - staubluftseitig | 108 Pa

# IfcFlowTreatmentDevice: Schalldämpfer (4)
In: RLT
Type - Description: Schalldämpfer
Schalldämpfer Eigenschaften - Schalldämpferlänge: 918 mm
Group: Kammer

# IfcSystem (8)
Description: Description
Name
Kammer | Filter Eigenschaften - Herstellertyp: KS50-L; Klasse: ePM10-55 % / M5; Eff. Klasse: E; Wartung: F - Schnellspann.; Auslegungsdruck: 67 Pa; Schalldämpfer Eigenschaften - Schalldämpferlänge: 918 mm; Stutzen Eigenschaften - Typ: Entkopplungsstutzen; Breite: 1.530 mm; Höhe: 1.530 mm; Material: Gummi
Kammer | Schalldämpfer Eigenschaften - Schalldämpferlänge: 918 mm; Ventilator Eigenschaften - # Einheiten: 1; Herstellertyp: RLM EVO; Volumenstrom: 18.000 m³/h; stat. Druckerhöhung: 694 Pa; Gehäusewiderstand: 20 Pa; Wellenleistung: 4,51 kW; stat. Wirkungsgrad: 77 %; tot. Wirkungsgrad: 81 %; Betriebsdrehzahl: 1.048 1/min; Belastungsgrenze: 1.670 1/min; Baugröße: 132; Regelungsart: FU; Betriebsfrequenz: 35 Hz; Max. Frequenz: 38 Hz; Volumen-/Drehzahl-Reserve: 8 %; Leistung PM: 4,99 kW; Leistung PM-FU: 5,52 kW; IE2: 1; Wirkungsgradklasse: IE 3; SFP Wert (GEG 2020): 751 W/(m³/s); SFPv (EN 16798-3): 1.051 W/(m³/s); SFP Klasse (EN 16798-3): SFP 3; Geschw.-Klasse (EN13053): V4; Nenn-Spannung: 400/690 V; Netzfrequenz: 50 Hz; Nennleistung(en): 7,5 kW; Nennstrom: 14,3/ 8,3 A; Nenndrehzahl(en): 1470 /min; Schutzklasse: IP55; Überlastsicherung: Kaltleiter; Isolationsklasse: F; P Klasse: P1; Systemwirkungsgrad: 61 %; Buchsen-Nummer: 2012; Ø Buchse: 38 mm; Schallleistungspegel Eintritt: 77,0 dB(A); Schallleistungspegel Austritt: 81,6 dB(A)
Kammer | Filter Eigenschaften - Herstellertyp: NW85-L; Klasse: ePM1-60 % / F7; Eff. Klasse: A; Wartung: F - Schnellspann.; Auslegungsdruck: 108 Pa; Stutzen Eigenschaften - Typ: Lamellenhaube; Breite: 20 AT4 Raster; Höhe: 20 AT4 Raster; Gesamtdrehmoment: 15,00 Nm
Kammer | Schalldämpfer Eigenschaften - Schalldämpferlänge: 918 mm; Ventilator Eigenschaften - # Einheiten: 1; Herstellertyp: RLM EVO; Volumenstrom: 18.000 m³/h; stat. Druckerhöhung: 1.022 Pa; Gehäusewiderstand: 30 Pa; Wellenleistung: 6,67 kW; stat. Wirkungsgrad: 77 %; tot. Wirkungsgrad: 81 %; Betriebsdrehzahl: 1.479 1/min; Belastungsgrenze: 1.880 1/min; Baugröße: 132; Regelungsart: FU; Betriebsfrequenz: 50 Hz; Max. Frequenz: 52 Hz; Volumen-/Drehzahl-Reserve: 4 %; Leistung PM: 7,38 kW; Leistung PM-FU: 7,79 kW; IE2: 1; Wirkungsgradklasse: IE 3; SFP Wert (GEG 2020): 1.106 W/(m³/s); SFPv (EN 16798-3): 1.406 W/(m³/s); SFP Klasse (EN 16798-3): SFP 3; Geschw.-Klasse (EN13053): V4; Nenn-Spannung: 400/690 V; Netzfrequenz: 50 Hz; Nennleistung(en): 7,5 kW; Nennstrom: 14,3/ 8,3 A; Nenndrehzahl(en): 1470 /min; Schutzklasse: IP55; Überlastsicherung: Kaltleiter; Isolationsklasse: F; P Klasse: P1; Systemwirkungsgrad: 64 %; Buchsen-Nummer: 2012; Ø Buchse: 38 mm; Schallleistungspegel Eintritt: 81,8 dB(A); Schallleistungspegel Austritt: 86,6 dB(A)
Kammer | Stutzen Eigenschaften - Typ: Klappe, innen; Breite: 1.341,0 mm; Höhe: 1.453 mm; Gesamtdrehmoment: 15,00 Nm
Kammer | Filter Eigenschaften - Herstellertyp: NW85-L; Klasse: ePM1-60 % / F7; Eff. Klasse: A; Wartung: S - staubluftseitig; Auslegungsdruck: 108 Pa; Stutzen Eigenschaften - Typ: Entkopplungsstutzen; Breite: 1.530 mm; Höhe: 1.530 mm; Material: Gummi
Kammer | Wärmetauscher Eigenschaften - Typ: Sorption; Ges. Wärmeleistung: 195,0 kW; Rückwärmzahl: 74,0 %; Rückfeuchtzahl: 71,5 %; WRG-Klasse (EN 13053/2020): H2; Wirkungsgrad (ausgegl., trocken): 74,0 %; Betriebszustand: 1; Δ Druck (Z): 143,3 Pa; Temperatur IN: -10,0 °C; Rel. Feuchte IN: 60,0 %; Abs. Feuchte IN: 1,0 g/kgL; Temperatur OUT: 12,9 °C; Rel. Feuchte OUT: 50,8 %; Abs. Feuchte OUT: 4,7 g/kgL
Kammer | Schalldämpfer Eigenschaften - Schalldämpferlänge: 918 mm; Wärmetauscher Eigenschaften - Ges. Wärmeleistung: 64,81 kW; Luftwiderstand (trocken): 105 Pa; Luftgeschwindigkeit: 2,57 m/s; Eintrittstemperatur: 26,6 °C; Relative Eintrittsfeuchte: 55,8 %; Abs. Eintrittsfeuchte: 12,2 g/kgL; Austrittstemperatur: 17,0 °C; Rel. Austrittsfeuchte: 97 %; Abs. Austrittsfeuchte: 11,8 g/kgL; Leistungsreserve: 35 %; Volumenstrom: 18.000 m³/h; Medium Eintrittstemperatur: 12,0 °C; Medium Austrittstemperatur: 18,0 °C; Max. Betriebsdruck: 16 bar; Mediumwiderstand: 7 kPa; Füllmenge: 58,3 l; Umwälzmenge: 9.274 l/h; Medium: Wasser; Glykol Anteil: 0 %; Rohre: Cu; Rohrreihen: 8; Kreise: 76; Lamellen: Al; Δ Lamellen: 2,5 mm; Sammler: Cu; Rahmen: Al; Einbausatz: Edelstahl (1.4301); Anschlüsse pro Kreislauf: 2; Anschlussweite: DN 80 (R 3); Anschlussart: A - gerade; Frostschutzrahmen: ohne; Beschreibung: Tr_UL_Cooler
